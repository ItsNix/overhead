/**
 * Elecrow CrowPanel 7.0" (basic DIS08070H or Advance) — aircraft over my home
 *
 * Left: a north-up radar centred on home with range rings, each aircraft drawn
 * as a heading-rotated icon colored by altitude, with callsign / altitude label
 * and a short trail. Positions are dead-reckoned between polls so they glide.
 * Right: clock, the nearest aircraft (tap one, on the radar or in the list,
 * for details), feed status and range buttons.
 * While no aircraft are airborne within range, the colorclock face is shown
 * instead (background = time as RGB); tap it to peek at the radar.
 *
 * Data source (web UI):
 *   - a local ADS-B receiver (readsb / dump1090 / tar1090 aircraft.json), and/or
 *   - an online aggregator: adsb.lol (default) or airplanes.live (/v2/point/lat/lon/radius);
 *     airplanes.live serves only its feeders (by IP); others get 403 unless approved by email
 *   "Auto" uses the receiver when it answers and falls back to the online feed.
 * Fetching runs in its own task on core 0, so slow HTTPS never stalls drawing.
 *
 * Configurable via web UI at http://overhead.local (or device IP): home
 * location, range, data source, labels / trails, time zone, brightness, dim and
 * off schedules, and the overhead card / beep. Range, brightness, schedules and
 * overhead options are also on screen: tap the top-left and top-right
 * corners within 5 s.
 *
 * Libraries (install via Library Manager):
 *   - LovyanGFX   by lovyan03
 *   - WiFiManager by tzapu
 *   - ArduinoJson by Benoit Blanchon (v7)
 *   (Preferences, WebServer, HTTPClient, ESPmDNS, Wire are built-in to the ESP32 core.)
 *
 * Build as "ESP32S3 Dev Module" with OPI PSRAM (see README.md for full FQBNs).
 * Board selection and all display / touch hardware details live in crowpanel7.h/.cpp.
 */

#include <WiFi.h>
#include <WiFiManager.h>
#include <WebServer.h>
#include <HTTPClient.h>
#include <WiFiClientSecure.h>
#include <ESPmDNS.h>
#include <Preferences.h>
#include <ArduinoJson.h>
#include <time.h>
#include <sys/time.h>
#include <esp_sntp.h>
#include "crowpanel7.h"
#include "fonts.h"        // smooth fonts, generated by tools/make_fonts.py
#include "smooth_font.h"
#include "app_types.h"

// Defined further down; Arduino's generated prototypes miss these.
void buildGammaLut();
bool cardShowing();
void closestApproach(const Aircraft& a, float& dNm, float& tSec);
void closeCard(const char* why);
void startPortal(const char* reason);

// Drawing a smooth-font glyph alloca()s its whole bitmap.
SET_LOOP_TASK_STACK_SIZE(FONTS_MAX_GLYPH_BYTES + 12 * 1024);

// ── Defaults ─────────────────────────────────────────────────────────────────
const char* DEFAULT_NTP        = "pool.ntp.org";
const char* DEFAULT_TZ         = "MST7MDT,M3.2.0,M11.1.0";   // Mountain Time w/ DST
const char* AP_NAME            = "Overhead-Setup";
const char* AP_PASSWORD        = "overhead";      // min 8 chars for WPA2
const char* HOSTNAME           = "overhead";      // DHCP hostname
const char* MDNS_NAME          = "overhead";      // → http://overhead.local
#if defined(BOARD_CROWPANEL_7)
const float DEFAULT_GAMMA      = 1.8f;    // TN panel: darken pale mid-tones
#else
const float DEFAULT_GAMMA      = 1.0f;    // IPS: start uncorrected, tune in the web UI
#endif
const float MIN_GAMMA          = 1.0f;
const float MAX_GAMMA          = 3.0f;
// Default home: Pocatello, Idaho (change it in the web UI).
const double DEFAULT_LAT       = 42.8713;
const double DEFAULT_LON       = -112.4455;
const char* USER_AGENT         = "overhead-esp32/1.0 (+https://github.com/ItsNix/overhead)";

// Range presets (nm) for the radar, and overhead radius presets (statute miles).
const uint16_t RANGE_CHOICES[] = {2, 5, 10, 15, 25, 50, 100, 150, 250};
const uint8_t  RANGE_COUNT     = sizeof(RANGE_CHOICES) / sizeof(RANGE_CHOICES[0]);
const uint16_t OVERHEAD_CHOICES[] = {1, 2, 3, 5};
const uint8_t  OVERHEAD_COUNT  = sizeof(OVERHEAD_CHOICES) / sizeof(OVERHEAD_CHOICES[0]);
const float    NM_PER_MI       = 0.868976f;
const char*    PROVIDER_NAMES[] = {"airplanes.live", "adsb.lol"};
// ─────────────────────────────────────────────────────────────────────────────

#define WIFI_RESET_WINDOW_MS 3000   // how long the boot splash waits for a touch
#define WIFI_RESET_HOLD_MS   2000   // how long the touch must be held

#define MAX_AIRCRAFT     128        // nearest kept per fetch
#define MAX_TRAILS       128
#define TRAIL_MIN_NM     0.03f      // skip trail points closer than this to the last one
#define TRAIL_EXPIRE_MS  120000     // forget a trail this long after its aircraft vanished
#define MAX_EXTRAP_S     30.0f      // dead-reckon at most this far past the last position
#define STALE_MS         60000      // feed older than this is shown as stale
#define REDRAW_MS        500        // radar frame interval (positions are extrapolated)
#define SELECT_MS        30000      // a tapped aircraft stays selected this long
#define ALERT_FORGET_MS  600000     // an aircraft can beep again after this long away
#define CARD_EXIT_FACTOR 1.25f      // card may close once the aircraft is this far past the radius
#define CARD_LEAD_S      60         // open this long before the predicted closest approach
#define CARD_MIN_MS      45000      // keep the card up at least this long (unless tapped / gone)
#define RANGE_SAVE_MS    5000       // range buttons save to NVS after this long idle
#define CLOCK_AFTER_MS   20000      // empty sky this long -> color clock
#define PEEK_MS          30000      // a tap on the color clock shows the radar this long
#define TIME_SUFFIX_GAP  16         // px between clock-face digits and AM/PM (matches make_fonts.py)

// Layout: radar on the left, info panel on the right.
#define RADAR_CX   240
#define RADAR_CY   240
#define RADAR_R    228
#define PANEL_X    480
#define PANEL_W    (SCREEN_W - PANEL_X)
#define LIST_Y     128
#define LIST_ROW_H 54
#define LIST_ROWS  5
#define STATUS_Y   410
#define RANGE_Y    428
#define RANGE_BTN_H 46

CrowPanel7  display;
LGFX_Sprite spr;      // always bound to the display's off-screen framebuffer

void bindSprite() {
  spr.setBuffer(display.backBuffer(), SCREEN_W, SCREEN_H, 16);
}

// Put the finished frame on screen and point the sprite at the next back buffer.
void presentFrame() {
  display.present();
  bindSprite();
}

// ── Smooth fonts (anti-aliased VLW, parsed once at boot from fonts.h) ──────
SmoothFont font16, font20, font24, font32, font40, font56, fontTime;
SmoothFont fontTimeL, fontTimeM, fontTimeS;   // clock face: no secs / 24h+secs / 12h+secs

void loadFonts() {
  font16.load(FONT_TEXT_16);
  font20.load(FONT_TEXT_20);
  font24.load(FONT_TEXT_24);
  font32.load(FONT_TEXT_32);
  font40.load(FONT_TEXT_40);
  font56.load(FONT_TEXT_56);
  fontTime.load(FONT_TIME);
  fontTimeL.load(FONT_TIME_L);
  fontTimeM.load(FONT_TIME_M);
  fontTimeS.load(FONT_TIME_S);
}

void useFont(SmoothFont& f) {
  spr.setFont(&f.font);
  spr.setTextSize(1);
}
WebServer   server(80);
Preferences prefs;

// ── Settings (persisted in NVS) ──────────────────────────────────────────────
struct Settings {
  String   ntp_server;
  String   tz_string;
  bool     format_24h;
  bool     color_clock;  // color clock face while no aircraft are in range
  bool     show_seconds; // clock face
  bool     show_date;    // clock face
  float    gamma;        // clock face background; 1.0 = off
  uint8_t  brightness;   // normal backlight, percent
  bool     dim_enabled;  // dim schedule
  uint16_t dim_start;    // minutes after midnight
  uint16_t dim_end;
  uint8_t  dim_level;    // backlight while dimmed, percent
  bool     off_enabled;  // screen-off schedule (wins where it overlaps dim)
  uint16_t off_start;
  uint16_t off_end;
  uint16_t wake_s;       // how long a tap brightens the screen when dim / off
  double   home_lat;     // 0,0 = not set
  double   home_lon;
  uint16_t range_nm;     // radar radius, one of RANGE_CHOICES
  uint8_t  source;       // Source
  uint8_t  provider;     // Provider
  String   local_url;    // receiver: host, or full aircraft.json URL
  uint16_t poll_s;       // seconds between fetches
  bool     labels;       // callsign / altitude next to each aircraft
  bool     trails;
  uint16_t overhead_mi;  // "overhead" radius, statute miles
  bool     show_card;    // full-screen card while an aircraft is overhead
  bool     alert;        // also beep (buzzer boards)
} settings;

// ms since a millis() timestamp. Timestamps stored as "millis() | 1" (so 0
// can mean "never") may be 1 ms in the future; that reads as 0, not ~49 days.
uint32_t msSince(uint32_t t) {
  int32_t d = (int32_t)(millis() - t);
  return d < 0 ? 0 : d;
}

bool homeSet() { return settings.home_lat != 0 || settings.home_lon != 0; }

// Smallest poll interval: local receivers are cheap; be polite to the free APIs.
uint16_t minPoll(uint8_t source) { return source == SRC_LOCAL ? 1 : 5; }

uint16_t nearestChoice(uint16_t v, const uint16_t* choices, uint8_t n) {
  for (int i = 0; i < n; i++) if (choices[i] >= v) return choices[i];
  return choices[n - 1];
}

void loadSettings() {
  prefs.begin("overhead", true);
  settings.ntp_server   = prefs.getString("ntp",   DEFAULT_NTP);
  settings.tz_string    = prefs.getString("tz",    DEFAULT_TZ);
  settings.format_24h   = prefs.getBool  ("fmt24", true);
  settings.color_clock  = prefs.getBool  ("cclock", true);
  settings.show_seconds = prefs.getBool  ("secs",  true);
  settings.show_date    = prefs.getBool  ("date",  true);
  settings.gamma        = constrain(prefs.getFloat("gamma", DEFAULT_GAMMA), MIN_GAMMA, MAX_GAMMA);
  settings.brightness   = prefs.getUChar ("bright", 100);
  settings.dim_enabled  = prefs.getBool  ("dim",    false);
  settings.dim_start    = prefs.getUShort("dstart", 20 * 60);
  settings.dim_end      = prefs.getUShort("dend",   22 * 60);
  settings.dim_level    = prefs.getUChar ("dlevel", 30);
  settings.off_enabled  = prefs.getBool  ("off",    false);
  settings.off_start    = prefs.getUShort("ostart", 22 * 60);
  settings.off_end      = prefs.getUShort("oend",   7 * 60);
  settings.wake_s       = prefs.getUShort("wake",   30);
  settings.home_lat     = prefs.getDouble("lat",    DEFAULT_LAT);
  settings.home_lon     = prefs.getDouble("lon",    DEFAULT_LON);
  settings.range_nm     = nearestChoice(prefs.getUShort("range", 25), RANGE_CHOICES, RANGE_COUNT);
  settings.source       = min<uint8_t>(prefs.getUChar("src", SRC_AUTO), SRC_ONLINE);
  settings.provider     = min<uint8_t>(prefs.getUChar("prov", PROV_ADSB_LOL), PROV_ADSB_LOL);
  settings.local_url    = prefs.getString("url",    "");
  settings.poll_s       = max(prefs.getUShort("poll", 5), minPoll(settings.source));
  settings.labels       = prefs.getBool  ("labels", true);
  settings.trails       = prefs.getBool  ("trails", true);
  settings.alert        = prefs.getBool  ("alert",  false);
  settings.overhead_mi  = nearestChoice(prefs.getUShort("ovmi", 1), OVERHEAD_CHOICES, OVERHEAD_COUNT);
  settings.show_card    = prefs.getBool  ("card",   true);
  prefs.end();
}

void saveSettings() {
  prefs.begin("overhead", false);
  prefs.putString("ntp",   settings.ntp_server);
  prefs.putString("tz",    settings.tz_string);
  prefs.putBool  ("fmt24", settings.format_24h);
  prefs.putBool  ("cclock", settings.color_clock);
  prefs.putBool  ("secs",  settings.show_seconds);
  prefs.putBool  ("date",  settings.show_date);
  prefs.putFloat ("gamma", settings.gamma);
  prefs.putUChar ("bright", settings.brightness);
  prefs.putBool  ("dim",    settings.dim_enabled);
  prefs.putUShort("dstart", settings.dim_start);
  prefs.putUShort("dend",   settings.dim_end);
  prefs.putUChar ("dlevel", settings.dim_level);
  prefs.putBool  ("off",    settings.off_enabled);
  prefs.putUShort("ostart", settings.off_start);
  prefs.putUShort("oend",   settings.off_end);
  prefs.putUShort("wake",   settings.wake_s);
  prefs.putDouble("lat",    settings.home_lat);
  prefs.putDouble("lon",    settings.home_lon);
  prefs.putUShort("range",  settings.range_nm);
  prefs.putUChar ("src",    settings.source);
  prefs.putUChar ("prov",   settings.provider);
  prefs.putString("url",    settings.local_url);
  prefs.putUShort("poll",   settings.poll_s);
  prefs.putBool  ("labels", settings.labels);
  prefs.putBool  ("trails", settings.trails);
  prefs.putBool  ("alert",  settings.alert);
  prefs.putUShort("ovmi",   settings.overhead_mi);
  prefs.putBool  ("card",   settings.show_card);
  prefs.end();
}

const char* sourceName(uint8_t s) {
  return s == SRC_LOCAL ? "local" : s == SRC_ONLINE ? "online" : "auto";
}

void logSettings(const char* what) {
  Serial.printf("%s: ntp=%s tz=%s 24h=%d clock=%d secs=%d date=%d gamma=%.1f bright=%u%% dim=%d %s-%s at %u%% off=%d %s-%s wake=%us "
                "home=%.5f,%.5f range=%unm src=%s prov=%s url=%s poll=%us labels=%d trails=%d "
                "overhead=%umi card=%d beep=%d\n", what,
                settings.ntp_server.c_str(), settings.tz_string.c_str(), settings.format_24h,
                settings.color_clock, settings.show_seconds, settings.show_date, settings.gamma,
                settings.brightness,
                settings.dim_enabled, hhmm(settings.dim_start).c_str(), hhmm(settings.dim_end).c_str(),
                settings.dim_level,
                settings.off_enabled, hhmm(settings.off_start).c_str(), hhmm(settings.off_end).c_str(),
                settings.wake_s, settings.home_lat, settings.home_lon, settings.range_nm,
                sourceName(settings.source), PROVIDER_NAMES[settings.provider],
                settings.local_url.c_str(), settings.poll_s, settings.labels, settings.trails,
                settings.overhead_mi, settings.show_card, settings.alert);
}

// Set from the SNTP task on each sync; loop() copies the time into the RTC
// (I2C stays on the loop task, which also owns touch and backlight).
volatile bool ntpSynced = false;
bool wifiOnline = false;

// True once the clock has been set, by the RTC or NTP (anything after 2024-01-01).
bool timeKnown() { return time(nullptr) > 1704067200; }

// Local time without waiting. Not getLocalTime(&ti, 0): its loop runs only while
// millis() - start <= 0, so it fails whenever millis() ticks between its two
// reads (~1 in 1000 calls). loop() then drew one "Waiting for the time" frame,
// which looks like the boot splash, and briefly dropped the dim/off schedule.
bool localTimeNow(struct tm* ti) {
  time_t now = time(nullptr);
  localtime_r(&now, ti);
  return timeKnown();
}

void applyTimeSettings() {
  // ESP32 built-in SNTP — handles DST via POSIX TZ string
  configTzTime(settings.tz_string.c_str(), settings.ntp_server.c_str());
  sntp_set_time_sync_notification_cb([](struct timeval*) { ntpSynced = true; });
}

// Battery-backed RTC (Advance board only): sets the clock at boot, before NTP.
void restoreTimeFromRtc() {
  time_t utc;
  if (!display.readRtc(utc)) {
    Serial.println("RTC: none, or no valid time");
    return;
  }
  timeval tv = { utc, 0 };
  settimeofday(&tv, nullptr);
  Serial.printf("RTC: %s", asctime(gmtime(&utc)));   // UTC; asctime ends in '\n'
}

// ── Colors ──────────────────────────────────────────────────────────────────
uint16_t rgb888to565(uint8_t r, uint8_t g, uint8_t b) {
  return ((uint16_t)(r & 0xF8) << 8) |
         ((uint16_t)(g & 0xFC) << 3) |
         ((uint16_t)(b >> 3));
}

// HSL (h in degrees, s / l 0..1) to RGB565.
uint16_t hsl565(float h, float s, float l, float scale = 1.0f) {
  float c = (1 - fabsf(2 * l - 1)) * s;
  float hp = fmodf(h, 360.0f) / 60.0f;
  float x = c * (1 - fabsf(fmodf(hp, 2.0f) - 1));
  float r = 0, g = 0, b = 0;
  if      (hp < 1) { r = c; g = x; }
  else if (hp < 2) { r = x; g = c; }
  else if (hp < 3) { g = c; b = x; }
  else if (hp < 4) { g = x; b = c; }
  else if (hp < 5) { r = x; b = c; }
  else             { r = c; b = x; }
  float m = l - c / 2;
  return rgb888to565((uint8_t)((r + m) * 255 * scale), (uint8_t)((g + m) * 255 * scale),
                     (uint8_t)((b + m) * 255 * scale));
}

// Altitude color ramp like tar1090's: orange low, green ~10k ft, through blue to magenta high.
uint16_t altColor(int32_t alt, float scale = 1.0f) {
  if (alt == ALT_GROUND)  return rgb888to565(110 * scale, 110 * scale, 110 * scale);
  if (alt == ALT_UNKNOWN) return rgb888to565(200 * scale, 200 * scale, 200 * scale);
  float h;
  if      (alt <= 2000)  h = 20;
  else if (alt <= 10000) h = 20 + (alt - 2000) * (120.0f / 8000.0f);
  else if (alt <= 40000) h = 140 + (alt - 10000) * (160.0f / 30000.0f);
  else                   h = 300;
  return hsl565(h, 0.85f, 0.58f, scale);
}

const uint16_t COL_BG       = 0x0000;
uint16_t COL_RADAR_OUT, COL_RADAR_IN, COL_RING, COL_RING_TEXT, COL_PANEL, COL_ROW,
         COL_DIM_TEXT, COL_ACCENT, COL_HOME, COL_ALERT, COL_WARN;

void initColors() {
  COL_RADAR_OUT = rgb888to565(6, 9, 16);
  COL_RADAR_IN  = rgb888to565(10, 18, 28);
  COL_RING      = rgb888to565(30, 62, 74);
  COL_RING_TEXT = rgb888to565(70, 120, 135);
  COL_PANEL     = rgb888to565(16, 20, 30);
  COL_ROW       = rgb888to565(26, 32, 46);
  COL_DIM_TEXT  = rgb888to565(140, 150, 165);
  COL_ACCENT    = rgb888to565(102, 204, 255);
  COL_HOME      = rgb888to565(80, 230, 255);
  COL_ALERT     = rgb888to565(255, 80, 80);
  COL_WARN      = rgb888to565(255, 170, 60);
}

// ── Calendar / formatting ───────────────────────────────────────────────────
const char* dayNames[]   = {"Sun","Mon","Tue","Wed","Thu","Fri","Sat"};
const char* monthNames[] = {"Jan","Feb","Mar","Apr","May","Jun",
                              "Jul","Aug","Sep","Oct","Nov","Dec"};

String pad2(int n) { return (n < 10 ? "0" : "") + String(n); }

String formatTime(const struct tm& ti) {
  if (settings.format_24h) return pad2(ti.tm_hour) + ":" + pad2(ti.tm_min) + ":" + pad2(ti.tm_sec);
  int h12 = ti.tm_hour % 12; if (h12 == 0) h12 = 12;
  return String(h12) + ":" + pad2(ti.tm_min) + ":" + pad2(ti.tm_sec) + (ti.tm_hour < 12 ? " AM" : " PM");
}

// "HH:MM" <-> minutes after midnight (for the schedule time inputs)
String hhmm(uint16_t minutes) { return pad2(minutes / 60) + ":" + pad2(minutes % 60); }

int parseHHMM(const String& s) {
  int colon = s.indexOf(':');
  if (colon < 1) return -1;
  int h = s.substring(0, colon).toInt(), m = s.substring(colon + 1).toInt();
  if (h < 0 || h > 23 || m < 0 || m > 59) return -1;
  return h * 60 + m;
}

// "FL350" at and above 18,000 ft (US transition altitude), else "4,500".
String altString(int32_t alt) {
  if (alt == ALT_GROUND)  return "GND";
  if (alt == ALT_UNKNOWN) return "---";
  if (alt >= 18000) {
    char b[8]; snprintf(b, sizeof(b), "FL%03ld", (long)((alt + 50) / 100)); return b;
  }
  char b[12];
  if (alt >= 1000 || alt <= -1000) snprintf(b, sizeof(b), "%ld,%03ld", (long)(alt / 1000), (long)labs(alt % 1000));
  else snprintf(b, sizeof(b), "%ld", (long)alt);
  return b;
}

const char* compass8(float bearing) {
  static const char* dirs[] = {"N", "NE", "E", "SE", "S", "SW", "W", "NW"};
  return dirs[(int)((bearing + 22.5f) / 45.0f) & 7];
}

String nmString(float nm) {
  return nm < 10 ? String(nm, 1) : String((int)lroundf(nm));
}

// Callsign, else registration, else hex.
String aircraftName(const Aircraft& a) {
  if (a.flight[0]) return a.flight;
  if (a.reg[0])    return a.reg;
  String h = a.hex; h.toUpperCase(); return h;
}

// ── Geometry ────────────────────────────────────────────────────────────────
const double DEG = M_PI / 180.0;

float distanceNm(double lat1, double lon1, double lat2, double lon2) {
  double dlat = (lat2 - lat1) * DEG, dlon = (lon2 - lon1) * DEG;
  double a = sin(dlat / 2) * sin(dlat / 2) +
             cos(lat1 * DEG) * cos(lat2 * DEG) * sin(dlon / 2) * sin(dlon / 2);
  return (float)(2 * atan2(sqrt(a), sqrt(1 - a)) * 3440.065);   // Earth radius in nm
}

float bearingDeg(double lat1, double lon1, double lat2, double lon2) {
  double dlon = (lon2 - lon1) * DEG;
  double y = sin(dlon) * cos(lat2 * DEG);
  double x = cos(lat1 * DEG) * sin(lat2 * DEG) - sin(lat1 * DEG) * cos(lat2 * DEG) * cos(dlon);
  double b = atan2(y, x) / DEG;
  return (float)(b < 0 ? b + 360 : b);
}

// Where the aircraft is probably now: last position moved along its track at
// its ground speed (not on the ground; at most MAX_EXTRAP_S).
void extrapolate(const Aircraft& a, uint32_t now, double& lat, double& lon) {
  lat = a.lat; lon = a.lon;
  if (a.gs <= 0 || a.track < 0 || a.alt == ALT_GROUND) return;
  float dt = (now - a.fetched) / 1000.0f + a.seen_pos;
  if (dt > MAX_EXTRAP_S) dt = MAX_EXTRAP_S;
  double d = a.gs * dt / 3600.0;   // nm
  lat += d * cos(a.track * DEG) / 60.0;
  lon += d * sin(a.track * DEG) / (60.0 * cos(lat * DEG));
}

// Flat projection around home (fine at these ranges), north up.
float radarScale() { return (float)RADAR_R / settings.range_nm; }   // px per nm

void project(double lat, double lon, float& x, float& y) {
  float s = radarScale();
  x = RADAR_CX + (float)((lon - settings.home_lon) * 60.0 * cos(settings.home_lat * DEG)) * s;
  y = RADAR_CY - (float)((lat - settings.home_lat) * 60.0) * s;
}

bool insideRadar(float x, float y, float margin = 0) {
  float dx = x - RADAR_CX, dy = y - RADAR_CY, r = RADAR_R - margin;
  return dx * dx + dy * dy <= r * r;
}

// ── Aircraft feed (fetch task on core 0) ────────────────────────────────────
// The task fills its own buffer, then publishes it under dataMutex; loop()
// copies it out when feedVersion changes.
SemaphoreHandle_t dataMutex;
TaskHandle_t      fetchTaskHandle = nullptr;
FetchConfig       fetchCfg;               // guarded by dataMutex

struct FeedStatus {
  uint32_t version = 0;   // bumped on every attempt
  uint32_t okAt = 0;      // millis() of the last successful fetch; 0 = never
  int      count = 0;     // aircraft within range (kept, up to MAX_AIRCRAFT)
  int      total = 0;     // aircraft in the response
  char     source[20] = "";
  char     error[64] = "";
};
FeedStatus feedShared;                    // guarded by dataMutex
Aircraft*  feedAc = nullptr;              // guarded by dataMutex

// What loop() draws from.
FeedStatus feed;
Aircraft*  viewAc = nullptr;
int        viewCount = 0;

struct PsramAllocator : ArduinoJson::Allocator {
  void* allocate(size_t n) override { return heap_caps_malloc(n, MALLOC_CAP_SPIRAM); }
  void deallocate(void* p) override { heap_caps_free(p); }
  void* reallocate(void* p, size_t n) override { return heap_caps_realloc(p, n, MALLOC_CAP_SPIRAM); }
} psramAllocator;

void publishFetchConfig(bool fetchNow) {
  xSemaphoreTake(dataMutex, portMAX_DELAY);
  fetchCfg.lat      = settings.home_lat;
  fetchCfg.lon      = settings.home_lon;
  fetchCfg.home_set = homeSet();
  fetchCfg.range_nm = settings.range_nm;
  fetchCfg.source   = settings.source;
  fetchCfg.provider = settings.provider;
  fetchCfg.poll_s   = settings.poll_s;
  strlcpy(fetchCfg.local_url, settings.local_url.c_str(), sizeof(fetchCfg.local_url));
  xSemaphoreGive(dataMutex);
  if (fetchNow && fetchTaskHandle) xTaskNotifyGive(fetchTaskHandle);
}

// "192.168.1.50" → "http://192.168.1.50/data/aircraft.json"; full URLs are kept.
String localFeedUrl(const char* in) {
  String u = in;
  u.trim();
  if (u.indexOf("://") < 0) u = "http://" + u;
  if (u.indexOf(".json") < 0) {
    while (u.endsWith("/")) u.remove(u.length() - 1);
    u += "/data/aircraft.json";
  }
  return u;
}

String onlineFeedUrl(const FetchConfig& cfg) {
  // Ask a little past the radar edge so aircraft entering are already known.
  int radius = min(250, (int)ceilf(cfg.range_nm * 1.2f) + 1);
  char url[128];
  snprintf(url, sizeof(url), "https://%s/v2/point/%.4f/%.4f/%d",
           cfg.provider == PROV_ADSB_LOL ? "api.adsb.lol" : "api.airplanes.live",
           cfg.lat, cfg.lon, radius);
  return url;
}

// Only the fields we use are kept while parsing, so large feeds stay small.
JsonDocument& feedFilter() {
  static JsonDocument filter;
  if (filter.isNull()) {
    filter["now"] = true;
    for (const char* list : {"ac", "aircraft"}) {
      JsonObject f = filter[list].add<JsonObject>();
      for (const char* k : {"hex", "flight", "t", "r", "squawk", "category", "lat", "lon",
                            "alt_baro", "alt_geom", "gs", "track", "true_heading",
                            "baro_rate", "geom_rate", "seen_pos"}) {
        f[k] = true;
      }
    }
  }
  return filter;
}

void copyTrimmed(char* dst, size_t n, const char* src) {
  strlcpy(dst, src ? src : "", n);
  for (int i = strlen(dst) - 1; i >= 0 && dst[i] == ' '; i--) dst[i] = 0;
}

int cmpDist(const void* a, const void* b) {
  float d = ((const Aircraft*)a)->dist_nm - ((const Aircraft*)b)->dist_nm;
  return d < 0 ? -1 : d > 0 ? 1 : 0;
}

#define MAX_BODY_BYTES (3 * 1024 * 1024)

// Reads the whole response body into a PSRAM buffer (caller frees). Reading the
// TLS socket directly from the parser hit "no data yet" mid-body and stopped.
// Chunked bodies are decoded in place.
uint8_t* readBody(HTTPClient& http, size_t& len, String& err) {
  NetworkClient* in = http.getStreamPtr();
  int expected = http.getSize();                 // -1 when chunked / unknown
  bool chunked = http.header("Transfer-Encoding").equalsIgnoreCase("chunked");
  size_t cap = expected > 0 ? expected + 1 : 64 * 1024;
  if (cap > MAX_BODY_BYTES) { err = "response too large"; return nullptr; }
  uint8_t* buf = (uint8_t*)heap_caps_malloc(cap, MALLOC_CAP_SPIRAM);
  len = 0;
  uint32_t last = millis();
  while (buf && (expected < 0 || (int)len < expected)) {
    int avail = in->available();
    if (avail <= 0) {
      if (!in->connected()) break;
      if (millis() - last > 8000) { err = "read timeout"; heap_caps_free(buf); return nullptr; }
      delay(5);
      continue;
    }
    if (len + avail > cap) {
      size_t ncap = max(cap * 2, len + avail);
      if (ncap > MAX_BODY_BYTES) { err = "response too large"; heap_caps_free(buf); return nullptr; }
      uint8_t* nb = (uint8_t*)heap_caps_realloc(buf, ncap, MALLOC_CAP_SPIRAM);
      if (!nb) break;
      buf = nb; cap = ncap;
    }
    int n = in->read(buf + len, avail);
    if (n > 0) { len += n; last = millis(); }
    // A kept-alive connection never closes, so stop at the last (empty) chunk.
    if (chunked && len >= 5 && !memcmp(buf + len - 5, "0\r\n\r\n", 5)) break;
  }
  if (!buf) { err = "out of memory"; return nullptr; }
  if (expected > 0 && (int)len < expected) { err = "short read"; heap_caps_free(buf); return nullptr; }

  if (chunked) {
    size_t r = 0, w = 0;
    while (r < len) {
      size_t size = strtoul((const char*)buf + r, nullptr, 16);
      while (r < len && buf[r] != '\n') r++;
      r++;                                       // past the size line
      if (size == 0 || r + size > len) break;
      memmove(buf + w, buf + r, size);
      w += size; r += size + 2;                  // data, then CRLF
    }
    len = w;
  }
  return buf;
}

// GETs url and returns the body in PSRAM (caller frees with heap_caps_free),
// or nullptr with err set.
uint8_t* httpGet(const String& url, size_t& len, String& err) {
  bool https = url.startsWith("https://");
  WiFiClient plain;
  WiFiClientSecure tls;
  // No certificate check: the feeds are public, read-only data.
  if (https) tls.setInsecure();
  HTTPClient http;
  const char* keep[] = {"Transfer-Encoding"};
  http.collectHeaders(keep, 1);
  http.setConnectTimeout(4000);
  http.setTimeout(8000);
  http.setUserAgent(USER_AGENT);
  http.setReuse(false);          // "Connection: close", so the server ends the body by closing
  if (!(https ? http.begin(tls, url) : http.begin(plain, url))) { err = "bad URL"; return nullptr; }
  int code = http.GET();
  if (code != HTTP_CODE_OK) {
    err = code < 0 ? HTTPClient::errorToString(code) : "HTTP " + String(code);
    http.end();
    return nullptr;
  }
  uint8_t* body = readBody(http, len, err);
  http.end();
  return body;
}

// GETs a readsb-style JSON feed ("ac" or "aircraft" array) and keeps the
// nearest MAX_AIRCRAFT with a recent position within range, sorted by distance.
bool fetchFeed(const String& url, const FetchConfig& cfg, Aircraft* out, int& count, int& total,
               String& err) {
  count = total = 0;
  size_t len;
  uint8_t* body = httpGet(url, len, err);
  if (!body) return false;
  JsonDocument doc(&psramAllocator);
  DeserializationError e = deserializeJson(doc, (const char*)body, len,
                                           DeserializationOption::Filter(feedFilter()));
  heap_caps_free(body);
  if (e) { err = String("JSON: ") + e.c_str(); return false; }

  JsonArray list = doc["ac"].as<JsonArray>();
  if (list.isNull()) list = doc["aircraft"].as<JsonArray>();
  if (list.isNull() && doc["now"].isNull()) { err = "not an aircraft feed"; return false; }

  uint32_t now = millis();
  float maxDist = cfg.range_nm * 1.2f + 1;
  for (JsonObject a : list) {
    total++;
    if (!a["lat"].is<double>() || !a["lon"].is<double>()) continue;
    float seen = a["seen_pos"] | 0.0f;
    if (seen > 60) continue;
    Aircraft x = {};
    x.lat = a["lat"]; x.lon = a["lon"];
    x.dist_nm = distanceNm(cfg.lat, cfg.lon, x.lat, x.lon);
    if (x.dist_nm > maxDist) continue;
    x.bearing = bearingDeg(cfg.lat, cfg.lon, x.lat, x.lon);
    x.seen_pos = seen;
    x.fetched = now;
    copyTrimmed(x.hex,    sizeof(x.hex),    a["hex"]);
    copyTrimmed(x.flight, sizeof(x.flight), a["flight"]);
    copyTrimmed(x.type,   sizeof(x.type),   a["t"]);
    copyTrimmed(x.reg,    sizeof(x.reg),    a["r"]);
    copyTrimmed(x.squawk, sizeof(x.squawk), a["squawk"]);
    copyTrimmed(x.cat,    sizeof(x.cat),    a["category"]);
    JsonVariant ab = a["alt_baro"];
    if (ab.is<int>())                                                x.alt = ab;
    else if (ab.is<const char*>() && !strcmp(ab.as<const char*>(), "ground")) x.alt = ALT_GROUND;
    else if (a["alt_geom"].is<int>())                                x.alt = a["alt_geom"];
    else                                                             x.alt = ALT_UNKNOWN;
    x.gs    = a["gs"].is<float>() ? (int16_t)lroundf(a["gs"].as<float>()) : -1;
    x.track = a["track"].is<float>()        ? (int16_t)lroundf(a["track"].as<float>()) % 360
            : a["true_heading"].is<float>() ? (int16_t)lroundf(a["true_heading"].as<float>()) % 360
            : -1;
    x.rate  = a["baro_rate"].is<int>() ? a["baro_rate"].as<int>() : a["geom_rate"] | 0;

    if (count < MAX_AIRCRAFT) {
      out[count++] = x;
    } else {   // full: replace the farthest if this one is nearer
      int far = 0;
      for (int i = 1; i < count; i++) if (out[i].dist_nm > out[far].dist_nm) far = i;
      if (x.dist_nm < out[far].dist_nm) out[far] = x;
    }
  }
  qsort(out, count, sizeof(Aircraft), cmpDist);
  return true;
}

// ── Overhead card lookups (fetch task) ─────────────────────────────────────
CardRequest cardReq = {};                 // guarded by dataMutex
CardInfo    cardShared = {};              // guarded by dataMutex; its jpg belongs to the task
uint32_t    cardVersion = 0;              // guarded by dataMutex

#define MAX_PHOTO_BYTES (400 * 1024)

JsonDocument* getJson(const String& url, String& err) {
  size_t len;
  uint8_t* body = httpGet(url, len, err);
  if (!body) return nullptr;
  JsonDocument* doc = new JsonDocument(&psramAllocator);
  DeserializationError e = deserializeJson(*doc, (const char*)body, len);
  heap_caps_free(body);
  if (e) { err = String("JSON: ") + e.c_str(); delete doc; return nullptr; }
  return doc;
}

void airportFields(JsonObject ap, char* code, size_t codeLen, char* city, size_t cityLen) {
  const char* iata = ap["iata"] | "";
  strlcpy(code, *iata ? iata : (ap["icao"] | ""), codeLen);
  const char* loc = ap["location"] | "";
  strlcpy(city, *loc ? loc : (ap["name"] | ""), cityLen);
}

// adsb.lol's route database, by callsign. Multi-stop routes ("JAC-DEN-CVG")
// pick the leg the aircraft is on: the one it adds the least distance to.
void lookupRoute(const CardRequest& r, CardInfo& c) {
  String cs = r.callsign;
  if (cs.length() < 3) return;
  String err;
  JsonDocument* doc = getJson("https://vrs-standing-data.adsb.lol/routes/" + cs.substring(0, 2) + "/" +
                              cs + ".json", err);
  if (!doc) { Serial.printf("Route %s: %s\n", r.callsign, err.c_str()); return; }
  JsonArray aps = (*doc)["_airports"];
  int n = aps.size(), best = -1;
  float bestCost = 1e9;
  for (int i = 0; i + 1 < n; i++) {
    double la0 = aps[i]["lat"], lo0 = aps[i]["lon"], la1 = aps[i + 1]["lat"], lo1 = aps[i + 1]["lon"];
    float cost = distanceNm(la0, lo0, r.lat, r.lon) + distanceNm(r.lat, r.lon, la1, lo1) -
                 distanceNm(la0, lo0, la1, lo1);
    if (cost < bestCost) { bestCost = cost; best = i; }
  }
  // The route database can be stale (callsigns get reused): ignore a route
  // the aircraft is well off.
  if (best >= 0) {
    double la0 = aps[best]["lat"], lo0 = aps[best]["lon"], la1 = aps[best + 1]["lat"], lo1 = aps[best + 1]["lon"];
    float leg = distanceNm(la0, lo0, la1, lo1);
    if (bestCost > max(60.0f, leg * 0.3f)) {
      Serial.printf("Route %s: %s ignored, %.0f nm off it\n", r.callsign, (*doc)["_airport_codes_iata"] | "?", bestCost);
      best = -1;
    }
  }
  if (best >= 0) {
    airportFields(aps[best],     c.from_code, sizeof(c.from_code), c.from_city, sizeof(c.from_city));
    airportFields(aps[best + 1], c.to_code,   sizeof(c.to_code),   c.to_city,   sizeof(c.to_city));
  }
  delete doc;
}

// hexdb.io: manufacturer, model and registered owner by ICAO address.
void lookupAircraft(const String& hex, CardInfo& c) {
  String err;
  JsonDocument* doc = getJson("https://hexdb.io/api/v1/aircraft/" + hex, err);
  if (!doc) { Serial.printf("Aircraft %s: %s\n", hex.c_str(), err.c_str()); return; }
  String maker = (*doc)["Manufacturer"] | "", type = (*doc)["Type"] | "";
  String model = type.startsWith(maker) ? type : maker + " " + type;
  model.trim();
  strlcpy(c.model, model.c_str(), sizeof(c.model));
  strlcpy(c.owner, (*doc)["RegisteredOwners"] | "", sizeof(c.owner));
  delete doc;
}

// planespotters.net: the first photo's 420x280 thumbnail and its photographer.
void lookupPhoto(const String& hex, CardInfo& c) {
  String err;
  JsonDocument* doc = getJson("https://api.planespotters.net/pub/photos/hex/" + hex, err);
  if (!doc) { Serial.printf("Photo %s: %s\n", hex.c_str(), err.c_str()); return; }
  JsonObject photo = (*doc)["photos"][0];
  String src = photo["thumbnail_large"]["src"] | "";
  strlcpy(c.photographer, photo["photographer"] | "", sizeof(c.photographer));
  delete doc;
  if (!src.length()) return;
  // planespotters serves progressive JPEGs, which LovyanGFX's decoder (TJpgDec)
  // can't read; images.weserv.nl re-encodes them as baseline. Direct as fallback.
  String proxied = src;
  proxied.replace("https://", "");
  proxied = "https://images.weserv.nl/?url=" + proxied + "&w=420&h=280&fit=cover&output=jpg&q=85";
  size_t len;
  uint8_t* jpg = httpGet(proxied, len, err);
  if (!jpg) {
    Serial.printf("Photo proxy: %s\n", err.c_str());
    jpg = httpGet(src, len, err);
  }
  if (!jpg) { Serial.printf("Photo %s: %s\n", hex.c_str(), err.c_str()); return; }
  if (len > MAX_PHOTO_BYTES) { heap_caps_free(jpg); return; }
  c.jpg = jpg;
  c.jpg_len = len;
}

// Runs the lookups for a new card request, if there is one.
void serviceCardRequest() {
  CardRequest r;
  xSemaphoreTake(dataMutex, portMAX_DELAY);
  r = cardReq;
  bool need = r.hex[0] && strcmp(r.hex, cardShared.hex) != 0;
  xSemaphoreGive(dataMutex);
  if (!need || WiFi.status() != WL_CONNECTED) return;

  uint32_t start = millis();
  CardInfo c = {};
  strlcpy(c.hex, r.hex, sizeof(c.hex));
  String hex = r.hex;
  hex.toUpperCase();
  lookupRoute(r, c);
  lookupAircraft(hex, c);
  lookupPhoto(hex, c);
  c.done = true;
  Serial.printf("Card %s: %s-%s, %s, %s, photo %u bytes (%lu ms)\n", r.callsign, c.from_code, c.to_code,
                c.model, c.owner, (unsigned)c.jpg_len, (unsigned long)(millis() - start));

  xSemaphoreTake(dataMutex, portMAX_DELAY);
  if (cardShared.jpg) heap_caps_free(cardShared.jpg);
  cardShared = c;
  cardVersion++;
  xSemaphoreGive(dataMutex);
}

void fetchTask(void*) {
  Aircraft* work = (Aircraft*)heap_caps_malloc(sizeof(Aircraft) * MAX_AIRCRAFT, MALLOC_CAP_SPIRAM);
  for (;;) {
    serviceCardRequest();
    FetchConfig cfg;
    xSemaphoreTake(dataMutex, portMAX_DELAY);
    cfg = fetchCfg;
    xSemaphoreGive(dataMutex);

    if (cfg.home_set && WiFi.status() == WL_CONNECTED) {
      int count = 0, total = 0;
      String err, src;
      bool ok = false;
      bool haveLocal = cfg.local_url[0] != 0;
      if (cfg.source != SRC_ONLINE && haveLocal) {
        src = "receiver";
        ok = fetchFeed(localFeedUrl(cfg.local_url), cfg, work, count, total, err);
        if (!ok) err = "receiver: " + err;
      }
      if (cfg.source == SRC_LOCAL && !haveLocal) err = "no receiver URL set";
      if (!ok && cfg.source != SRC_LOCAL) {
        String localErr = err;
        src = PROVIDER_NAMES[cfg.provider];
        ok = fetchFeed(onlineFeedUrl(cfg), cfg, work, count, total, err);
        if (ok && localErr.length()) err = localErr;   // fell back: keep the reason visible
        else if (!ok) err = src + ": " + err;
      }
      if (ok) Serial.printf("Feed: %s, %d of %d aircraft in range%s%s\n", src.c_str(), count, total,
                            err.length() ? "; " : "", err.c_str());
      else    Serial.printf("Feed failed: %s\n", err.c_str());

      xSemaphoreTake(dataMutex, portMAX_DELAY);
      feedShared.version++;
      if (ok) {
        memcpy(feedAc, work, sizeof(Aircraft) * count);
        feedShared.count = count;
        feedShared.total = total;
        feedShared.okAt  = millis() | 1;
        strlcpy(feedShared.source, src.c_str(), sizeof(feedShared.source));
      }
      strlcpy(feedShared.error, err.c_str(), sizeof(feedShared.error));
      xSemaphoreGive(dataMutex);
    }
    // Sleep until the next poll, or until settings change.
    ulTaskNotifyTake(pdTRUE, pdMS_TO_TICKS(max<uint16_t>(cfg.poll_s, 1) * 1000UL));
  }
}

void startFetchTask() {
  dataMutex = xSemaphoreCreateMutex();
  feedAc = (Aircraft*)heap_caps_calloc(MAX_AIRCRAFT, sizeof(Aircraft), MALLOC_CAP_SPIRAM);
  viewAc = (Aircraft*)heap_caps_calloc(MAX_AIRCRAFT, sizeof(Aircraft), MALLOC_CAP_SPIRAM);
  publishFetchConfig(false);
  // TLS handshakes need a deep stack; core 0 is where WiFi runs anyway.
  xTaskCreatePinnedToCore(fetchTask, "fetch", 20 * 1024, nullptr, 1, &fetchTaskHandle, 0);
}

// Copies a new feed result into the view; true if there was one.
bool pullFeed() {
  bool fresh = false;
  xSemaphoreTake(dataMutex, portMAX_DELAY);
  if (feedShared.version != feed.version) {
    fresh = feedShared.okAt != feed.okAt;
    feed = feedShared;
    if (fresh) {
      memcpy(viewAc, feedAc, sizeof(Aircraft) * feedShared.count);
      viewCount = feedShared.count;
    }
  }
  xSemaphoreGive(dataMutex);
  return fresh;
}

// ── Trails ──────────────────────────────────────────────────────────────────
Trail* trails = nullptr;          // MAX_TRAILS, PSRAM

Trail* findTrail(const char* hex) {
  for (int i = 0; i < MAX_TRAILS; i++) if (trails[i].hex[0] && !strcmp(trails[i].hex, hex)) return &trails[i];
  return nullptr;
}

void updateTrails() {
  uint32_t now = millis();
  for (int i = 0; i < viewCount; i++) {
    const Aircraft& a = viewAc[i];
    Trail* t = findTrail(a.hex);
    if (!t) {
      for (int j = 0; j < MAX_TRAILS && !t; j++) if (!trails[j].hex[0]) t = &trails[j];
      if (!t) continue;
      memset(t, 0, sizeof(Trail));
      strlcpy(t->hex, a.hex, sizeof(t->hex));
    }
    t->lastSeen = now;
    if (t->n) {
      int last = (t->head + TRAIL_POINTS - 1) % TRAIL_POINTS;
      if (distanceNm(t->lat[last], t->lon[last], a.lat, a.lon) < TRAIL_MIN_NM) continue;
    }
    t->lat[t->head] = a.lat;
    t->lon[t->head] = a.lon;
    t->head = (t->head + 1) % TRAIL_POINTS;
    if (t->n < TRAIL_POINTS) t->n++;
  }
  for (int j = 0; j < MAX_TRAILS; j++) {
    if (trails[j].hex[0] && now - trails[j].lastSeen > TRAIL_EXPIRE_MS) trails[j].hex[0] = 0;
  }
}

// ── Status / boot screens ───────────────────────────────────────────────────
void drawStatus(const String& l1, const String& l2, uint16_t color) {
  spr.fillSprite(TFT_BLACK);
  spr.setTextDatum(MC_DATUM);
  spr.setTextColor(color, TFT_BLACK);
  useFont(font56);
  if (l2.length() == 0) {
    spr.drawString(l1, SCREEN_W/2, SCREEN_H/2);
  } else {
    spr.drawString(l1, SCREEN_W/2, SCREEN_H/2 - 40);
    useFont(font40);
    spr.setTextColor(TFT_WHITE, TFT_BLACK);
    spr.drawString(l2, SCREEN_W/2, SCREEN_H/2 + 40);
  }
}

void showStatus(const String& l1, const String& l2 = "", uint16_t color = TFT_CYAN) {
  drawStatus(l1, l2, color);
  presentFrame();
}

void portalCallback(WiFiManager* wm) {
  spr.fillSprite(TFT_BLUE);
  spr.setTextDatum(MC_DATUM);
  spr.setTextColor(TFT_WHITE, TFT_BLUE);
  useFont(font56);
  spr.drawString("WiFi Setup", SCREEN_W/2, 55);
  useFont(font40);
  spr.drawString("Connect phone to:", SCREEN_W/2, 140);
  useFont(font56);
  spr.setTextColor(TFT_YELLOW, TFT_BLUE);
  spr.drawString(AP_NAME, SCREEN_W/2, 215);
  useFont(font40);
  spr.setTextColor(TFT_WHITE, TFT_BLUE);
  spr.drawString(String("Password: ") + AP_PASSWORD, SCREEN_W/2, 300);
  spr.drawString("Then open: 192.168.4.1", SCREEN_W/2, 365);
  useFont(font24);
  spr.drawString("(captive portal will appear)", SCREEN_W/2, 430);
  presentFrame();
}

// ── Touch-hold WiFi reset at boot ───────────────────────────────────────────
// Shows a splash for WIFI_RESET_WINDOW_MS; returns true if the screen is held
// for WIFI_RESET_HOLD_MS, with a progress bar while it's held.
bool wifiResetRequested() {
  const int barX = 100, barY = SCREEN_H - 60, barW = SCREEN_W - 200, barH = 24;
  uint32_t start = millis(), heldSince = 0;
  while (true) {
    uint32_t now = millis();
    bool touched = display.touched();
    if (touched && heldSince == 0) heldSince = now;
    if (!touched) heldSince = 0;
    uint32_t held = touched ? now - heldSince : 0;

    drawStatus("Overhead", "Touch & hold to reset WiFi", TFT_CYAN);
    if (touched) {
      spr.drawRect(barX - 2, barY - 2, barW + 4, barH + 4, TFT_WHITE);
      spr.fillRect(barX, barY, min<uint32_t>(held, WIFI_RESET_HOLD_MS) * barW / WIFI_RESET_HOLD_MS,
                   barH, TFT_RED);
    }
    presentFrame();   // paced by the panel's frame rate

    if (touched && held >= WIFI_RESET_HOLD_MS) return true;
    if (!touched && now - start >= WIFI_RESET_WINDOW_MS) return false;
  }
}

// ── Touch (polled once per loop pass) ───────────────────────────────────────
struct TouchState {
  bool down    = false;   // finger on the screen
  bool started = false;   // went down this pass
  int  x = 0, y = 0;      // last position while down
} touch;

void pollTouch() {
  int x, y;
  bool down = display.touchPoint(x, y);
  touch.started = down && !touch.down;
  touch.down = down;
  if (down) { touch.x = x; touch.y = y; }
  if (touch.started) Serial.printf("Touch at %d,%d\n", x, y);
}

// ── Dim / off schedules ─────────────────────────────────────────────────────
// start..end in minutes after midnight; may span midnight; equal = never.
bool inWindow(bool enabled, uint16_t start, uint16_t end, const struct tm& ti) {
  if (!enabled || start == end) return false;
  int now = ti.tm_hour * 60 + ti.tm_min;
  if (start < end) return now >= start && now < end;
  return now >= start || now < end;
}

Schedule scheduleAt(const struct tm& ti) {
  if (inWindow(settings.off_enabled, settings.off_start, settings.off_end, ti)) return SCHED_OFF;
  if (inWindow(settings.dim_enabled, settings.dim_start, settings.dim_end, ti)) return SCHED_DIM;
  return SCHED_NORMAL;
}

uint8_t  backlightLevel = 0;   // percent last sent to the backlight
uint8_t  wakeLevel = 0;        // level a tap raised the screen to
uint32_t wakeUntil = 0;        // millis() deadline of that tap-to-wake; 0 = none
Schedule currentSchedule = SCHED_NORMAL;

void setBacklightLevel(uint8_t level, const char* why) {
  if (level == backlightLevel) return;   // on the Advance each change is an I2C write
  backlightLevel = level;
  display.setBrightness(level);
  Serial.printf("Backlight %u%% (%s)\n", level, why);
}

// Normal brightness, or the dim level / off per schedule. While dim or off a
// tap brightens one step for wake_s (off → dim level, dim → normal), re-armed
// while touching. Returns true if this touch only woke the screen.
bool updateScreenPower(Schedule sched) {
  uint8_t dimLevel  = min(settings.dim_level, settings.brightness);
  uint8_t scheduled = sched == SCHED_OFF ? 0 : sched == SCHED_DIM ? dimLevel : settings.brightness;

  if (wakeUntil && (int32_t)(millis() - wakeUntil) >= 0) wakeUntil = 0;
  uint8_t level = wakeUntil ? max(wakeLevel, scheduled) : scheduled;

  bool woke = false;
  if (touch.started && level < settings.brightness) {
    wakeLevel = level == 0 ? dimLevel : settings.brightness;
    woke = level == 0;
    level = wakeLevel;
    if (!wakeUntil) wakeUntil = 1;   // armed below
  }
  if (wakeUntil && touch.down) wakeUntil = (millis() + settings.wake_s * 1000UL) | 1;
  setBacklightLevel(level, wakeUntil ? "tapped" : sched == SCHED_OFF ? "off schedule"
                         : sched == SCHED_DIM ? "dim schedule" : "normal");
  return woke;
}

// ── Buzzer (boards with one): overhead alert ────────────────────────────────
// Two short beeps, stepped from loop() so drawing isn't held up.
#define BEEP_MS 120
uint8_t  beepStep = 0;        // counts down: odd = beeping, even = gap, 0 = idle
uint32_t beepNext = 0;        // millis() of the next step

void startBeep() {
  if (!CrowPanel7::hasBuzzer()) return;
  beepStep = 4;
  beepNext = millis();
}

void updateBeep() {
  if (!beepStep || (int32_t)(millis() - beepNext) < 0) return;
  beepStep--;
  display.setBuzzer(beepStep & 1);   // steps 3, 1 = on; 2, 0 = off
  beepNext = millis() + BEEP_MS;
}

// Aircraft that have come overhead recently, so each beeps once per pass.
struct AlertSeen { char hex[7]; uint32_t lastIn; };
AlertSeen alertSeen[32];

float overheadNm() { return settings.overhead_mi * NM_PER_MI; }

// Airborne and within the overhead radius (at fetch time).
bool inOverhead(const Aircraft& a) {
  return a.alt != ALT_GROUND && a.dist_nm <= overheadNm();
}

// Called with each new feed. Beeps for an airborne aircraft newly within
// the overhead radius, unless the screen is scheduled dim / off.
void checkAlerts() {
  uint32_t now = millis();
  bool beep = false;
  for (int i = 0; i < viewCount; i++) {
    const Aircraft& a = viewAc[i];
    if (!inOverhead(a)) continue;
    AlertSeen* slot = nullptr;
    AlertSeen* oldest = &alertSeen[0];
    for (auto& s : alertSeen) {
      if (s.hex[0] && !strcmp(s.hex, a.hex)) { slot = &s; break; }
      if (!s.hex[0] || s.lastIn < oldest->lastIn) oldest = &s;
    }
    if (slot && now - slot->lastIn < ALERT_FORGET_MS) { slot->lastIn = now; continue; }
    if (!slot) { slot = oldest; strlcpy(slot->hex, a.hex, sizeof(slot->hex)); }
    slot->lastIn = now;
    Serial.printf("Overhead: %s %s %.1f nm\n", aircraftName(a).c_str(), altString(a.alt).c_str(), a.dist_nm);
    beep = true;
  }
  if (beep && settings.alert && currentSchedule == SCHED_NORMAL) startBeep();
}

// ── Web UI ──────────────────────────────────────────────────────────────────
const char SETTINGS_HTML[] PROGMEM = R"HTML(
<!DOCTYPE html><html><head>
<meta charset="utf-8">
<meta name="viewport" content="width=device-width,initial-scale=1">
<title>Overhead</title>
<style>
*{box-sizing:border-box}
body{font-family:-apple-system,BlinkMacSystemFont,sans-serif;background:#111;color:#eee;padding:20px;max-width:520px;margin:auto;line-height:1.4}
h1{color:#6cf;margin-top:0}
h2{color:#6cf;font-size:16px;margin:25px 0 10px}
label{display:block;margin-top:14px;font-weight:600;font-size:14px}
input[type=text],input[type=time],input[type=number],select{width:100%;padding:10px;margin-top:5px;background:#222;color:#fff;border:1px solid #444;border-radius:4px;font-size:14px}
input[type=checkbox]{margin-right:8px;transform:scale(1.3);vertical-align:middle}
.cb{display:flex;align-items:center;margin-top:14px;font-weight:400}
.row{display:flex;gap:10px}.row>div{flex:1}
button{margin-top:20px;padding:12px;background:#6cf;color:#000;border:0;font-size:15px;border-radius:4px;cursor:pointer;width:100%;font-weight:600}
button:hover{background:#8df}
button.danger{background:#822;color:#fff}
button.danger:hover{background:#a33}
.status{background:#1a1a1a;padding:15px;border-radius:6px;margin-bottom:20px;font-size:13px;border:1px solid #333}
.status div{margin:3px 0;display:flex;justify-content:space-between;gap:10px}
.status span:first-child{color:#888;white-space:nowrap}
.status span:last-child{color:#fff;font-family:monospace;text-align:right}
input[type=range]{width:100%;margin-top:8px}
.hint{color:#888;font-size:12px;margin-top:4px}
.live{color:#6cf;font-size:18px}
.err{color:#f96!important}
hr{border:0;border-top:1px solid #333;margin:25px 0}
div#map{height:320px;margin-top:10px;border-radius:6px;background:#1a1a1a}
.leaflet-tile-pane{filter:invert(1) hue-rotate(180deg) brightness(.9) contrast(.9)}
.search{display:flex;gap:8px;margin-top:10px}
.search input{flex:1;margin-top:0!important}
.search button{width:auto;margin:0;padding:10px 16px}
</style>
<link rel="stylesheet" href="https://cdnjs.cloudflare.com/ajax/libs/leaflet/1.9.4/leaflet.min.css">
<script src="https://cdnjs.cloudflare.com/ajax/libs/leaflet/1.9.4/leaflet.min.js"></script></head><body>
<h1>Overhead</h1>

<div class="status">
<div><span>Current</span><span class="live" id="time">--:--:--</span></div>
<div><span>Feed</span><span id="feed">-</span></div>
<div><span>Feed error</span><span class="err" id="err"></span></div>
<div><span>Nearest</span><span id="near">-</span></div>
<div><span>Hostname</span><span>%MDNS%.local</span></div>
<div><span>IP</span><span>%IP%</span></div>
<div><span>WiFi</span><span>%RSSI%</span></div>
<div><span>Uptime</span><span>%UPTIME%</span></div>
<div><span>Screen</span><span>%SCREEN%</span></div>
</div>

<form action="/save" method="POST">

<h2>Home Location</h2>
<div class="row">
<div><label>Latitude</label><input type="text" name="lat" value="%LAT%" inputmode="decimal"></div>
<div><label>Longitude</label><input type="text" name="lon" value="%LON%" inputmode="decimal"></div>
</div>
<div class="search"><input type="text" id="q" placeholder="Search an address or place"><button type="button" id="find">Find</button></div>
<div id="map"><div class="hint" style="padding:12px">The map needs internet access in this browser; you can still type the coordinates.</div></div>
<div class="hint">Click the map or drag the pin to your house. Blue: radar range; red: overhead radius.</div>

<h2>Radar</h2>
<label>Range</label>
<select name="range" id="range">%RANGEOPTS%</select>
<label class="cb"><input type="checkbox" name="labels" %LABELS%> Callsign and altitude labels</label>
<label class="cb"><input type="checkbox" name="trails" %TRAILS%> Trails</label>

<h2>Data Source</h2>
<label>Use</label>
<select name="src">
<option value="0" %SRC0%>Auto: my receiver, else online</option>
<option value="1" %SRC1%>My receiver only</option>
<option value="2" %SRC2%>Online only</option>
</select>
<label>My receiver</label>
<input type="text" name="url" value="%URL%" placeholder="192.168.1.50 or http://pi.local/tar1090/data/aircraft.json">
<div class="hint">A readsb / dump1090 / tar1090 host. A bare host or URL gets <code>/data/aircraft.json</code> appended; dump1090-fa usually needs <code>host:8080</code>; tar1090 is <code>host/tar1090</code>. Receivers don't send aircraft type or registration.</div>
<label>Online feed</label>
<select name="prov">
<option value="1" %PROV1%>adsb.lol</option>
<option value="0" %PROV0%>airplanes.live (feeders only)</option>
</select>
<label>Update every (seconds)</label>
<input type="number" name="poll" min="1" max="120" value="%POLL%">
<div class="hint">At least 5 s whenever the online feed may be used (free, rate-limited APIs).</div>

<h2>Overhead</h2>
<label>An aircraft is overhead when it's within</label>
<select name="ovmi" id="ovmi">%OVOPTS%</select>
<div class="hint">Horizontal distance from home, at any altitude. Shown as a dashed circle on the radar and the map.</div>
<label class="cb"><input type="checkbox" name="card" %CARD%> Show a full-screen card about it</label>
<div class="hint">Route, aircraft, photo and live altitude / speed. Closes when it moves away, or tap it.</div>
<div %BEEPSTYLE%>
<label class="cb"><input type="checkbox" name="alert" %ALERT%> Beep</label>
<div class="hint">Once per aircraft; quiet while the screen is scheduled dim or off.</div>
<button type="button" onclick="fetch('/beep',{method:'POST'})">Test beep</button>
</div>

<h2>Color Clock</h2>
<label class="cb"><input type="checkbox" name="cclock" %CCLOCK%> Show the color clock while no aircraft are in range</label>
<div class="hint">Switches back to the radar as soon as an aircraft is airborne within range; tap the clock to look at the radar for 30 s.</div>
<label class="cb"><input type="checkbox" name="secs" %SECS%> Show seconds</label>
<label class="cb"><input type="checkbox" name="date" %DATE%> Show date line</label>
<label>Color richness (gamma): <span id="gv">%GAMMA%</span></label>
<input type="range" name="gamma" min="1.0" max="3.0" step="0.1" value="%GAMMA%"
       oninput="document.getElementById('gv').textContent=this.value">
<div class="hint">Higher darkens mid-tones for deeper colors on this panel. 1.0 = no correction.</div>

<h2>Time</h2>
<label>NTP Server</label>
<input type="text" name="ntp" value="%NTP%">
<label>Time Zone Preset</label>
<select onchange="if(this.value)document.querySelector('[name=tz]').value=this.value">
<option value="">— pick preset or use custom below —</option>
<option value="UTC0">UTC</option>
<option value="PST8PDT,M3.2.0,M11.1.0">US Pacific (PST/PDT)</option>
<option value="MST7MDT,M3.2.0,M11.1.0">US Mountain (MST/MDT)</option>
<option value="MST7">US Arizona (MST, no DST)</option>
<option value="CST6CDT,M3.2.0,M11.1.0">US Central (CST/CDT)</option>
<option value="EST5EDT,M3.2.0,M11.1.0">US Eastern (EST/EDT)</option>
<option value="HST10">Hawaii (HST)</option>
<option value="AKST9AKDT,M3.2.0,M11.1.0">Alaska (AKST/AKDT)</option>
<option value="GMT0BST,M3.5.0/1,M10.5.0">UK (GMT/BST)</option>
<option value="CET-1CEST,M3.5.0,M10.5.0/3">Central Europe (CET/CEST)</option>
<option value="EET-2EEST,M3.5.0/3,M10.5.0/4">Eastern Europe (EET/EEST)</option>
<option value="JST-9">Japan (JST)</option>
<option value="AEST-10AEDT,M10.1.0,M4.1.0/3">Sydney (AEST/AEDT)</option>
</select>
<label>POSIX TZ String</label>
<input type="text" name="tz" value="%TZ%">
<label class="cb"><input type="checkbox" name="fmt24" %FMT24%> 24-hour clock</label>

<h2>Screen</h2>
<label>Brightness: <span id="bv">%BRIGHT%</span>%</label>
<input type="range" name="bright" min="5" max="100" step="5" value="%BRIGHT%"
       oninput="document.getElementById('bv').textContent=this.value">

<h2>Dim Schedule</h2>
<label class="cb"><input type="checkbox" name="dim" %DIM%> Dim the screen</label>
<div class="row">
<div><label>From</label><input type="time" name="dstart" value="%DSTART%"></div>
<div><label>Until</label><input type="time" name="dend" value="%DEND%"></div>
</div>
<label>Dim brightness: <span id="dv">%DLEVEL%</span>%</label>
<input type="range" name="dlevel" min="5" max="100" step="5" value="%DLEVEL%"
       oninput="document.getElementById('dv').textContent=this.value">

<h2>Off Schedule</h2>
<label class="cb"><input type="checkbox" name="off" %OFF%> Turn the screen off</label>
<div class="row">
<div><label>From</label><input type="time" name="ostart" value="%OSTART%"></div>
<div><label>Until</label><input type="time" name="oend" value="%OEND%"></div>
</div>
<div class="hint">Takes priority where it overlaps the dim schedule.</div>
<label>Tap to wake for (seconds)</label>
<input type="number" name="wake" min="5" max="3600" value="%WAKE%">

<button type="submit">Save &amp; Apply</button>
</form>

<hr>

<form action="/wifi_setup" method="POST"
      onsubmit="return confirm('Open the Overhead-Setup hotspot to pick a different network?')">
<button type="submit">Change WiFi Network</button>
</form>
<form action="/reset_wifi" method="POST"
      onsubmit="return confirm('Wipe saved WiFi credentials and reboot?')">
<button type="submit" class="danger">Reset WiFi Credentials</button>
</form>

<script>
const tick=()=>{
  fetch('/status').then(r=>r.json()).then(s=>{
    document.getElementById('time').textContent=s.time;
    document.getElementById('feed').textContent=s.source?`${s.source}, ${s.count} in range (${s.total} received), ${s.age}s ago`:'no data yet';
    document.getElementById('err').textContent=s.error;
    document.getElementById('near').textContent=s.nearest||'-';
  }).catch(()=>{});
}
setInterval(tick,2000); tick();

// Map picker: Leaflet + OpenStreetMap tiles (no key; darkened by CSS), OSM Nominatim search.
(()=>{
  if(!window.L)return;
  const la=document.querySelector('[name=lat]'),lo=document.querySelector('[name=lon]');
  const rng=document.getElementById('range'),ov=document.getElementById('ovmi');
  const start=[parseFloat(la.value)||%DEFLAT%,parseFloat(lo.value)||%DEFLON%];
  const mapDiv=document.getElementById('map');mapDiv.innerHTML='';
  const map=L.map(mapDiv).setView(start,12);
  L.tileLayer('https://tile.openstreetmap.org/{z}/{x}/{y}.png',{maxZoom:19,
    attribution:'&copy; <a href="https://www.openstreetmap.org/copyright">OpenStreetMap</a> contributors'}).addTo(map);
  const pin=L.marker(start,{draggable:true}).addTo(map);
  const rc=L.circle(start,{radius:rng.value*1852,color:'#6cf',weight:1,fill:false}).addTo(map);
  const oc=L.circle(start,{radius:ov.value*1609.344,color:'#f66',weight:2,dashArray:'4 4',fillOpacity:0.08}).addTo(map);
  const place=(p,fromInputs)=>{
    pin.setLatLng(p);rc.setLatLng(p);oc.setLatLng(p);
    if(!fromInputs){la.value=p.lat.toFixed(5);lo.value=p.lng.toFixed(5);}
  }
  map.on('click',e=>place(e.latlng));
  pin.on('dragend',()=>place(pin.getLatLng()));
  [la,lo].forEach(i=>i.addEventListener('change',()=>{
    const p=L.latLng(parseFloat(la.value),parseFloat(lo.value));
    if(!isNaN(p.lat)&&!isNaN(p.lng)){place(p,true);map.panTo(p);}
  }));
  rng.addEventListener('change',()=>rc.setRadius(rng.value*1852));
  ov.addEventListener('change',()=>oc.setRadius(ov.value*1609.344));
  const find=()=>{
    const q=document.getElementById('q').value.trim();if(!q)return;
    fetch('https://nominatim.openstreetmap.org/search?format=json&limit=1&q='+encodeURIComponent(q))
      .then(r=>r.json()).then(j=>{
        if(!j.length){alert('Not found');return;}
        const p=L.latLng(+j[0].lat,+j[0].lon);place(p);map.setView(p,16);
      }).catch(()=>alert('Search failed'));
  }
  document.getElementById('find').onclick=find;
  document.getElementById('q').addEventListener('keydown',e=>{if(e.key==='Enter'){e.preventDefault();find();}});
})();
</script>
</body></html>
)HTML";

// ── Web handlers ────────────────────────────────────────────────────────────
String uptimeString() {
  long s = millis() / 1000;
  char buf[32];
  snprintf(buf, sizeof(buf), "%ldd %02ld:%02ld:%02ld",
           s/86400, (s%86400)/3600, (s%3600)/60, s%60);
  return String(buf);
}

String choiceOptions(const uint16_t* choices, uint8_t n, uint16_t current, const char* unit) {
  String out;
  for (int i = 0; i < n; i++) {
    out += "<option value=\"" + String(choices[i]) + "\"" + (choices[i] == current ? " selected" : "") +
           ">" + String(choices[i]) + " " + unit + "</option>";
  }
  return out;
}

String htmlEscape(const String& s) {
  String out;
  for (char c : s) {
    if (c == '&') out += "&amp;"; else if (c == '"') out += "&quot;";
    else if (c == '<') out += "&lt;"; else if (c == '>') out += "&gt;"; else out += c;
  }
  return out;
}

void handleRoot() {
  String html = FPSTR(SETTINGS_HTML);
  html.replace("%MDNS%",   MDNS_NAME);
  html.replace("%IP%",     WiFi.localIP().toString());
  html.replace("%RSSI%",   wifiOnline ? String(WiFi.RSSI()) + " dBm" : "offline");
  html.replace("%UPTIME%", uptimeString());
  html.replace("%LAT%",    homeSet() ? String(settings.home_lat, 5) : "");
  html.replace("%LON%",    homeSet() ? String(settings.home_lon, 5) : "");
  html.replace("%RANGEOPTS%", choiceOptions(RANGE_CHOICES, RANGE_COUNT, settings.range_nm, "nm"));
  html.replace("%LABELS%", settings.labels ? "checked" : "");
  html.replace("%TRAILS%", settings.trails ? "checked" : "");
  html.replace("%SRC0%",   settings.source == SRC_AUTO   ? "selected" : "");
  html.replace("%SRC1%",   settings.source == SRC_LOCAL  ? "selected" : "");
  html.replace("%SRC2%",   settings.source == SRC_ONLINE ? "selected" : "");
  html.replace("%URL%",    htmlEscape(settings.local_url));
  html.replace("%PROV0%",  settings.provider == PROV_AIRPLANES_LIVE ? "selected" : "");
  html.replace("%PROV1%",  settings.provider == PROV_ADSB_LOL       ? "selected" : "");
  html.replace("%POLL%",   String(settings.poll_s));
  html.replace("%ALERT%",  settings.alert ? "checked" : "");
  html.replace("%OVOPTS%", choiceOptions(OVERHEAD_CHOICES, OVERHEAD_COUNT, settings.overhead_mi, "mi"));
  html.replace("%CARD%",   settings.show_card ? "checked" : "");
  html.replace("%BEEPSTYLE%", CrowPanel7::hasBuzzer() ? "" : "style=\"display:none\"");
  html.replace("%DEFLAT%", String(DEFAULT_LAT, 4));
  html.replace("%DEFLON%", String(DEFAULT_LON, 4));
  html.replace("%NTP%",    htmlEscape(settings.ntp_server));
  html.replace("%TZ%",     htmlEscape(settings.tz_string));
  html.replace("%FMT24%",  settings.format_24h ? "checked" : "");
  html.replace("%CCLOCK%", settings.color_clock ? "checked" : "");
  html.replace("%SECS%",   settings.show_seconds ? "checked" : "");
  html.replace("%DATE%",   settings.show_date ? "checked" : "");
  html.replace("%GAMMA%",  String(settings.gamma, 1));
  html.replace("%BRIGHT%", String(settings.brightness));
  html.replace("%DIM%",    settings.dim_enabled ? "checked" : "");
  html.replace("%DSTART%", hhmm(settings.dim_start));
  html.replace("%DEND%",   hhmm(settings.dim_end));
  html.replace("%DLEVEL%", String(settings.dim_level));
  html.replace("%OFF%",    settings.off_enabled ? "checked" : "");
  html.replace("%OSTART%", hhmm(settings.off_start));
  html.replace("%OEND%",   hhmm(settings.off_end));
  html.replace("%WAKE%",   String(settings.wake_s));
  html.replace("%SCREEN%", backlightLevel == 0 ? String("Off (scheduled)")
                         : String(backlightLevel) + "%" + (wakeUntil ? " (tapped)"
                         : backlightLevel < settings.brightness ? " (dimmed)" : ""));
  server.send(200, "text/html", html);
}

bool configOpen = false;         // on-screen settings showing
bool portalOpen = false;         // WiFi setup portal running (on demand)
bool clockShowing = false;       // color clock face is on screen
bool radarDirty = true;           // redraw now, not at the next REDRAW_MS tick
uint32_t rangeSaveAt = 0;         // millis() to save after the range buttons; 0 = none

void handleSave() {
  if (server.hasArg("lat") && server.hasArg("lon")) {
    String la = server.arg("lat"), lo = server.arg("lon");
    la.trim(); lo.trim();
    double lat = la.toDouble(), lon = lo.toDouble();
    if (la.length() && lo.length() && lat >= -90 && lat <= 90 && lon >= -180 && lon <= 180) {
      if ((lat != settings.home_lat || lon != settings.home_lon) && cardShowing()) closeCard("home moved");
      settings.home_lat = lat;
      settings.home_lon = lon;
    }
  }
  if (server.hasArg("range")) settings.range_nm = nearestChoice(server.arg("range").toInt(), RANGE_CHOICES, RANGE_COUNT);
  settings.labels = server.hasArg("labels");
  settings.trails = server.hasArg("trails");
  if (server.hasArg("src"))  settings.source   = constrain(server.arg("src").toInt(), SRC_AUTO, SRC_ONLINE);
  if (server.hasArg("prov")) settings.provider = constrain(server.arg("prov").toInt(), PROV_AIRPLANES_LIVE, PROV_ADSB_LOL);
  if (server.hasArg("url"))  { settings.local_url = server.arg("url"); settings.local_url.trim(); }
  if (server.hasArg("poll")) settings.poll_s = constrain(server.arg("poll").toInt(), 1, 120);
  settings.poll_s = max(settings.poll_s, minPoll(settings.source));
  if (server.hasArg("ovmi")) settings.overhead_mi = nearestChoice(server.arg("ovmi").toInt(), OVERHEAD_CHOICES, OVERHEAD_COUNT);
  settings.show_card = server.hasArg("card");
  if (CrowPanel7::hasBuzzer()) settings.alert = server.hasArg("alert");
  if (server.hasArg("ntp")) settings.ntp_server = server.arg("ntp");
  if (server.hasArg("tz"))  settings.tz_string  = server.arg("tz");
  settings.format_24h = server.hasArg("fmt24");
  settings.color_clock  = server.hasArg("cclock");
  settings.show_seconds = server.hasArg("secs");
  settings.show_date    = server.hasArg("date");
  if (server.hasArg("gamma")) {
    settings.gamma = constrain(server.arg("gamma").toFloat(), MIN_GAMMA, MAX_GAMMA);
    buildGammaLut();
  }
  if (server.hasArg("bright")) settings.brightness = constrain(server.arg("bright").toInt(), 5, 100);
  int t;
  settings.dim_enabled = server.hasArg("dim");
  if ((t = parseHHMM(server.arg("dstart"))) >= 0) settings.dim_start = t;
  if ((t = parseHHMM(server.arg("dend")))   >= 0) settings.dim_end   = t;
  if (server.hasArg("dlevel")) settings.dim_level = constrain(server.arg("dlevel").toInt(), 5, 100);
  settings.off_enabled = server.hasArg("off");
  if ((t = parseHHMM(server.arg("ostart"))) >= 0) settings.off_start = t;
  if ((t = parseHHMM(server.arg("oend")))   >= 0) settings.off_end   = t;
  if (server.hasArg("wake")) settings.wake_s = constrain(server.arg("wake").toInt(), 5, 3600);
  saveSettings();
  rangeSaveAt = 0;
  applyTimeSettings();
  publishFetchConfig(true);
  radarDirty = true;
  logSettings("Saved");
  server.sendHeader("Location", "/");
  server.send(303);
}

void handleStatus() {
  JsonDocument doc;
  struct tm ti;
  doc["time"]   = getLocalTime(&ti, 20) ? formatTime(ti) : "--:--:--";
  doc["source"] = feed.source;
  doc["count"]  = viewCount;
  doc["total"]  = feed.total;
  doc["age"]    = feed.okAt ? (long)(msSince(feed.okAt) / 1000) : -1L;
  doc["error"]  = feed.error;
  doc["view"]   = cardShowing() ? "card" : clockShowing ? "clock" : "radar";
  if (viewCount) {
    const Aircraft& a = viewAc[0];
    doc["nearest"] = aircraftName(a) + " " + altString(a.alt) +
                     (a.alt > ALT_GROUND && a.alt < 18000 ? " ft, " : ", ") + nmString(a.dist_nm) +
                     " nm " + compass8(a.bearing);
  }
  String out;
  serializeJson(doc, out);
  server.send(200, "application/json", out);
}

// Diagnostic: the aircraft currently shown.
void handleAircraft() {
  JsonDocument doc;
  doc["source"] = feed.source;
  doc["age_s"]  = feed.okAt ? (long)(msSince(feed.okAt) / 1000) : -1L;
  JsonArray list = doc["aircraft"].to<JsonArray>();
  for (int i = 0; i < viewCount; i++) {
    const Aircraft& a = viewAc[i];
    JsonObject o = list.add<JsonObject>();
    o["hex"] = a.hex; o["flight"] = a.flight; o["type"] = a.type; o["reg"] = a.reg;
    o["lat"] = a.lat; o["lon"] = a.lon; o["alt"] = a.alt; o["gs"] = a.gs; o["track"] = a.track;
    o["rate"] = a.rate; o["squawk"] = a.squawk; o["cat"] = a.cat;
    o["dist_nm"] = serialized(String(a.dist_nm, 2)); o["bearing"] = (int)a.bearing;
  }
  String out;
  serializeJson(doc, out);
  server.send(200, "application/json", out);
}

// Opens the setup hotspot without forgetting the saved network.
void handleWiFiSetup() {
  server.send(200, "text/html",
    "<body style='font-family:sans-serif;background:#111;color:#eee;padding:30px'>"
    "<h1>WiFi setup</h1><p>Join the <b>Overhead-Setup</b> network (password <b>overhead</b>) "
    "and pick the new network. The display stays on the old one until then, and closes the "
    "setup after 10 minutes.</p></body>");
  delay(300);
  startPortal("Opened from the web page");
}

void handleResetWiFi() {
  server.send(200, "text/html",
    "<meta http-equiv='refresh' content='3'>"
    "<body style='font-family:sans-serif;background:#111;color:#eee;padding:30px'>"
    "<h1>Resetting WiFi…</h1><p>Device will reboot into setup mode.</p></body>");
  delay(800);
  WiFiManager wm;
  wm.resetSettings();
  delay(500);
  ESP.restart();
}

// Panel tuning (not persisted): /panel?mhz=26.67 sets the pixel clock live and
// reports the measured refresh rate; /panel alone just reports it.
void handlePanel() {
  String msg;
  if (server.hasArg("mhz")) {
    uint32_t hz = (uint32_t)(server.arg("mhz").toFloat() * 1e6f);
    bool ok = hz >= 8000000 && hz <= 40000000 && display.setPixelClock(hz);
    msg += String(ok ? "set pclk " : "rejected pclk ") + server.arg("mhz") + " MHz\n";
    delay(200);   // let the new clock take effect
  }
  msg += "fps=" + String(display.measureFps(), 1) + "\n";
  Serial.print("Panel: " + msg);
  server.send(200, "text/plain", msg);
}

// Diagnostic: /snap returns the on-screen framebuffer as raw RGB565 (byte-swapped,
// 800x480). Blocks the loop while sending, so the buffer can't change mid-transfer.
void handleSnap() {
  const uint8_t* fb = (const uint8_t*)display.frontBuffer();
  const size_t len = SCREEN_W * SCREEN_H * 2;
  server.setContentLength(len);
  server.send(200, "application/octet-stream", "");
  for (size_t off = 0; off < len; off += 4096) {
    server.sendContent((const char*)fb + off, min<size_t>(4096, len - off));
  }
}

void handleBeep() {
  startBeep();
  server.send(204);
}

void handleNotFound() {
  server.send(404, "text/plain", "Not found");
}

void setupWebServer() {
  server.on("/",          handleRoot);
  server.on("/save",      HTTP_POST, handleSave);
  server.on("/status",    handleStatus);
  server.on("/aircraft.json", handleAircraft);
  server.on("/reset_wifi",HTTP_POST, handleResetWiFi);
  server.on("/wifi_setup",HTTP_POST, handleWiFiSetup);
  server.on("/panel",     handlePanel);
  server.on("/snap",      handleSnap);
  server.on("/beep",      HTTP_POST, handleBeep);
  server.onNotFound(handleNotFound);
  server.begin();

  if (MDNS.begin(MDNS_NAME)) {
    MDNS.addService("http", "tcp", 80);
    Serial.printf("mDNS: http://%s.local\n", MDNS_NAME);
  }
}

// ── WiFi setup via WiFiManager ──────────────────────────────────────────────
#define WIFI_CONNECT_MS  20000   // boot: wait this long for saved credentials
#define WIFI_RETRY_MS    30000   // offline: reconnect attempt interval

// Boot only. With saved credentials that don't connect in time while the time
// is already known (Advance RTC), the setup portal opens in the background
// (bootPortal) so the network can be changed without pulling the RTC cell;
// the clock keeps running and loop() keeps retrying. Without the time, the
// blocking portal opens as before (nothing to show without WiFi anyway).
bool bootPortal = false;

void setupWiFi() {
  WiFiManager wm;
  wm.setConfigPortalTimeout(180);
  wm.setAPCallback(portalCallback);
  wm.setDebugOutput(false);

  // Set hostname BEFORE connecting so DHCP advertises it correctly
  WiFi.mode(WIFI_STA);
  WiFi.setHostname(HOSTNAME);

  if (wifiResetRequested()) {
    showStatus("Resetting WiFi", "credentials...", TFT_RED);
    wm.resetSettings();
    delay(1500);
  }

  bool connected = false;
  if (wm.getWiFiIsSaved()) {
    showStatus("Connecting WiFi", "(saved creds)");
    WiFi.begin();
    for (uint32_t start = millis(); millis() - start < WIFI_CONNECT_MS; delay(100)) {
      if (WiFi.status() == WL_CONNECTED) { connected = true; break; }
    }
    if (!connected && timeKnown()) {
      Serial.printf("WiFi: saved network \"%s\" didn't connect\n", wm.getWiFiSSID().c_str());
      bootPortal = true;
      return;
    }
  }

  if (!connected && !wm.startConfigPortal(AP_NAME, AP_PASSWORD)) {
    WiFi.mode(WIFI_STA);
    if (timeKnown()) {
      showStatus("Setup timeout", "Running offline", TFT_ORANGE);
      delay(2500);
      return;
    }
    showStatus("Setup timeout", "Restarting...", TFT_RED);
    delay(2000);
    ESP.restart();
  }

  wifiOnline = true;
  Serial.printf("WiFi connected: %s\n", WiFi.localIP().toString().c_str());
  showStatus("Connected!", WiFi.localIP().toString(), TFT_GREEN);
  delay(2000);
}

// Runs every loop pass: the display keeps going while WiFi is down, with a
// reconnect attempt every WIFI_RETRY_MS. On reconnect SNTP is restarted, which
// also corrects the RTC, and the feed is polled at once.
void checkWiFi() {
  static uint32_t lastTry = 0;
  bool up = WiFi.status() == WL_CONNECTED;
  if (up != wifiOnline) {
    wifiOnline = up;
    lastTry = millis();
    radarDirty = true;
    if (up) {
      Serial.printf("WiFi connected: %s\n", WiFi.localIP().toString().c_str());
      applyTimeSettings();
      publishFetchConfig(true);
    } else {
      Serial.println("WiFi lost; retrying in the background");
    }
  }
  if (!up && !portalOpen && millis() - lastTry >= WIFI_RETRY_MS) {
    lastTry = millis();
    WiFi.reconnect();
  }
}

// ── WiFi setup portal, on demand (non-blocking) ───────────────────────────
// Opened from the on-screen settings, the web UI, or at boot when the saved
// network doesn't connect but the clock has the time. Runs the WiFiManager
// hotspot alongside the clock until a network is saved, Cancel is tapped, or
// PORTAL_MS passes; then reconnects to the saved network.
#define PORTAL_MS (10 * 60 * 1000UL)

WiFiManager portalWm;
uint32_t    portalSince = 0;
String      portalReason;

void startPortal(const char* reason) {
  if (portalOpen) return;
  Serial.printf("WiFi setup portal opened (%s)\n", reason);
  portalReason = reason;
  server.stop();                       // the portal serves its own pages on port 80
  WiFi.setHostname(HOSTNAME);
  portalWm.setDebugOutput(false);
  portalWm.setConfigPortalBlocking(false);
  portalWm.setConfigPortalTimeout(0);  // ours, so the screen can count it down
  portalWm.startConfigPortal(AP_NAME, AP_PASSWORD);
  portalOpen = true;
  portalSince = millis();
  radarDirty = true;
}

void stopPortal(bool saved, const char* why) {
  if (!portalOpen) return;
  portalOpen = false;
  if (!saved) portalWm.stopConfigPortal();
  WiFi.mode(WIFI_STA);
  WiFi.setHostname(HOSTNAME);
  if (WiFi.status() != WL_CONNECTED) WiFi.begin();   // saved (maybe new) network
  server.begin();
  radarDirty = true;
  Serial.printf("WiFi setup portal closed (%s)\n", why);
}

#define PORTAL_BTN_X 520
#define PORTAL_BTN_Y 400
#define PORTAL_BTN_W 260
#define PORTAL_BTN_H 64

void drawPortal(const struct tm* ti) {
  uint32_t left = PORTAL_MS > msSince(portalSince) ? (PORTAL_MS - msSince(portalSince)) / 1000 : 0;
  spr.fillSprite(TFT_BLUE);
  spr.setTextDatum(MC_DATUM);
  spr.setTextColor(TFT_WHITE, TFT_BLUE);
  useFont(font40);
  spr.drawString("WiFi Setup", SCREEN_W / 2, 36);
  useFont(font20);
  spr.drawString(portalReason, SCREEN_W / 2, 76);
  useFont(font32);
  spr.drawString("On your phone, join:", SCREEN_W / 2, 130);
  useFont(font56);
  spr.setTextColor(TFT_YELLOW, TFT_BLUE);
  spr.drawString(AP_NAME, SCREEN_W / 2, 190);
  useFont(font32);
  spr.setTextColor(TFT_WHITE, TFT_BLUE);
  spr.drawString(String("Password: ") + AP_PASSWORD, SCREEN_W / 2, 250);
  spr.drawString("then pick your network", SCREEN_W / 2, 296);
  useFont(font20);
  spr.drawString("(page opens by itself, or go to 192.168.4.1)", SCREEN_W / 2, 336);

  spr.setTextDatum(ML_DATUM);
  String saved = portalWm.getWiFiSSID();
  spr.drawString(saved.length() ? "Saved network: " + saved : String("No saved network"), 24, 400);
  char t[40];
  snprintf(t, sizeof(t), "Closes in %lu:%02lu", (unsigned long)(left / 60), (unsigned long)(left % 60));
  spr.drawString(t, 24, 434);
  if (ti) {
    char clk[12];
    snprintf(clk, sizeof(clk), "%02d:%02d", ti->tm_hour, ti->tm_min);
    spr.drawString(String("Time ") + clk, 24, 464);
  }
  useFont(font32);
  spr.setTextDatum(MC_DATUM);
  spr.fillRoundRect(PORTAL_BTN_X, PORTAL_BTN_Y, PORTAL_BTN_W, PORTAL_BTN_H, 12, rgb888to565(58, 58, 66));
  spr.setTextColor(TFT_WHITE);
  spr.drawString("Cancel", PORTAL_BTN_X + PORTAL_BTN_W / 2, PORTAL_BTN_Y + PORTAL_BTN_H / 2);
  presentFrame();
}

// One loop pass while the portal is open.
void runPortal(const struct tm* ti) {
  if (portalWm.process())                 { stopPortal(true,  "connected to the new network"); return; }
  if (!portalWm.getConfigPortalActive())  { stopPortal(true,  "exit from the setup page"); return; }
  if (msSince(portalSince) >= PORTAL_MS)  { stopPortal(false, "timed out"); return; }
  if (touch.started && touch.x >= PORTAL_BTN_X && touch.y >= PORTAL_BTN_Y - 20) {
    stopPortal(false, "cancelled");
    return;
  }
  setBacklightLevel(settings.brightness, "wifi setup");
  static uint32_t lastDraw = 0;
  if (radarDirty || msSince(lastDraw) >= 1000) {
    radarDirty = false;
    lastDraw = millis() | 1;
    drawPortal(ti);
  } else {
    delay(10);
  }
}

String currentIp() {
  return WiFi.status() == WL_CONNECTED ? WiFi.localIP().toString() : String();
}

// ── Radar view ──────────────────────────────────────────────────────────────
char     selHex[7] = "";          // tapped aircraft; "" = none
uint32_t selUntil = 0;

// Screen positions from the last frame, for tap hit-testing.
struct Hit { int16_t x, y; int16_t index; };
Hit      hits[MAX_AIRCRAFT];
int      hitCount = 0;
int16_t  listIndex[LIST_ROWS];    // viewAc index per list row; -1 = empty
int      listCount = 0;

int findAircraft(const char* hex) {
  for (int i = 0; i < viewCount; i++) if (!strcmp(viewAc[i].hex, hex)) return i;
  return -1;
}

// Ring spacing: a round step giving 3-5 rings.
float ringStep(uint16_t range) {
  static const float steps[] = {50, 25, 10, 5, 2.5f, 2, 1, 0.5f};
  for (float s : steps) if (range / s >= 3) return s;
  return 0.5f;
}

String ringLabel(float nm) {
  return nm == (int)nm ? String((int)nm) : String(nm, 1);
}

// Plane silhouette as triangles, nose toward -y, ~24 units long.
const int8_t PLANE_TRIS[][6] = {
  {  0,-12,  -2, -7,   2, -7 },   // nose
  { -2, -7,   2, -7,   2,  8 },   // fuselage
  { -2, -7,   2,  8,  -2,  8 },
  { -2, -3, -12,  4,  -2,  3 },   // wings
  {  2, -3,  12,  4,   2,  3 },
  { -1,  6,  -6, 11,  -1,  9 },   // tailplane
  {  1,  6,   6, 11,   1,  9 },
  { -2,  8,   2,  8,   0, 11 },   // tail cone
};

void drawPlane(float cx, float cy, float trackDeg, float size, uint16_t col) {
  float s = size / 24.0f, c = cosf(trackDeg * DEG), n = sinf(trackDeg * DEG);
  for (auto& t : PLANE_TRIS) {
    int p[6];
    for (int k = 0; k < 6; k += 2) {
      float x = t[k] * s, y = t[k + 1] * s;
      p[k]     = lroundf(cx + x * c - y * n);
      p[k + 1] = lroundf(cy + x * n + y * c);
    }
    spr.fillTriangle(p[0], p[1], p[2], p[3], p[4], p[5], col);
  }
}

// Icon size from the emitter category (light ... heavy).
float planeSize(const Aircraft& a) {
  if (a.cat[0] == 'A') {
    switch (a.cat[1]) {
      case '1': return 18;
      case '2': return 21;
      case '5': return 30;
      case '6': return 26;   // high performance
    }
  }
  return 25;
}

void drawRadarBackground() {
  spr.fillRect(0, 0, PANEL_X, SCREEN_H, COL_RADAR_OUT);
  spr.fillCircle(RADAR_CX, RADAR_CY, RADAR_R, COL_RADAR_IN);
  float step = ringStep(settings.range_nm), s = radarScale();
  useFont(font16);
  spr.setTextColor(COL_RING_TEXT);
  spr.setTextDatum(BL_DATUM);
  for (float r = step; r <= settings.range_nm + 0.01f; r += step) {
    int pr = lroundf(r * s);
    spr.drawCircle(RADAR_CX, RADAR_CY, pr, COL_RING);
    // Label on the ring at 45 degrees (NE), clear of the cardinal letters.
    int lx = RADAR_CX + lroundf(pr * 0.7071f) + 3, ly = RADAR_CY - lroundf(pr * 0.7071f) - 2;
    spr.drawString(ringLabel(r) + (r + step > settings.range_nm + 0.01f ? " nm" : ""), lx, ly);
  }
  spr.drawFastHLine(RADAR_CX - RADAR_R, RADAR_CY, RADAR_R * 2, COL_RING);
  spr.drawFastVLine(RADAR_CX, RADAR_CY - RADAR_R, RADAR_R * 2, COL_RING);
  spr.setTextDatum(MC_DATUM);
  spr.setTextColor(COL_ACCENT);
  spr.drawString("N", RADAR_CX, RADAR_CY - RADAR_R + 12);

  if ((settings.show_card || (settings.alert && CrowPanel7::hasBuzzer())) &&
      overheadNm() < settings.range_nm) {
    int ar = lroundf(overheadNm() * s);
    uint16_t col = rgb888to565(90, 30, 34);
    for (int a = 0; a < 360; a += 10) {   // dashed
      float a0 = a * DEG, a1 = (a + 5) * DEG;
      spr.drawLine(RADAR_CX + ar * sinf(a0), RADAR_CY - ar * cosf(a0),
                   RADAR_CX + ar * sinf(a1), RADAR_CY - ar * cosf(a1), col);
    }
  }

  // Home
  spr.fillCircle(RADAR_CX, RADAR_CY, 5, COL_HOME);
  spr.drawCircle(RADAR_CX, RADAR_CY, 8, COL_HOME);
}

void drawTrail(const Aircraft& a, float nowX, float nowY) {
  Trail* t = findTrail(a.hex);
  if (!t || t->n == 0) return;
  uint16_t col = altColor(a.alt, 0.55f);
  float px = 0, py = 0;
  bool havePrev = false;
  for (int k = 0; k < t->n; k++) {
    int idx = (t->head + TRAIL_POINTS - t->n + k) % TRAIL_POINTS;
    float x, y;
    project(t->lat[idx], t->lon[idx], x, y);
    bool in = insideRadar(x, y);
    if (havePrev && in) spr.drawLine(px, py, x, y, col);
    px = x; py = y; havePrev = in;
  }
  if (havePrev) spr.drawLine(px, py, nowX, nowY, col);
}

#define LABEL_H 36

int labelWidth(const Aircraft& a) {
  useFont(font16);
  return max(spr.textWidth(aircraftName(a)), spr.textWidth(altString(a.alt)) + (abs(a.rate) >= 300 ? 12 : 0));
}

// Label at (lx, ly) top-left: name, then altitude with a climb / descent arrow.
void drawLabel(const Aircraft& a, int lx, int ly, int w, bool selected) {
  useFont(font16);
  if (selected) spr.fillRoundRect(lx - 4, ly - 2, w + 8, LABEL_H + 2, 4, rgb888to565(40, 60, 80));
  spr.setTextDatum(TL_DATUM);
  spr.setTextColor(TFT_WHITE);
  spr.drawString(aircraftName(a), lx, ly);
  uint16_t col = altColor(a.alt);
  spr.setTextColor(col);
  int aw = spr.drawString(altString(a.alt), lx, ly + 18);
  if (abs(a.rate) >= 300) {
    int ax = lx + aw + 6, ay = ly + 26;
    if (a.rate > 0) spr.fillTriangle(ax - 4, ay + 3, ax + 4, ay + 3, ax, ay - 4, col);
    else            spr.fillTriangle(ax - 4, ay - 3, ax + 4, ay - 3, ax, ay + 4, col);
  }
}

struct LabelBox { int16_t x, y, w; int16_t index; };

bool labelFree(const LabelBox* boxes, int n, int x, int y, int w) {
  for (int i = 0; i < n; i++) {
    const LabelBox& o = boxes[i];
    if (x < o.x + o.w + 6 && o.x < x + w + 6 && y < o.y + LABEL_H && o.y < y + LABEL_H) return false;
  }
  return true;
}

void drawAircraft(uint32_t now) {
  static float px[MAX_AIRCRAFT], py[MAX_AIRCRAFT];
  static bool  shown[MAX_AIRCRAFT];
  static LabelBox boxes[MAX_AIRCRAFT];
  hitCount = 0;
  int selIdx = selHex[0] ? findAircraft(selHex) : -1;

  for (int i = 0; i < viewCount; i++) {
    double lat, lon;
    extrapolate(viewAc[i], now, lat, lon);
    project(lat, lon, px[i], py[i]);
    shown[i] = insideRadar(px[i], py[i], 4);
  }

  // Labels are placed nearest first (selected before all), right of the icon
  // or else left of it, and skipped where they would overlap one already placed.
  int nBoxes = 0;
  for (int k = -1; k < viewCount; k++) {
    int i = k < 0 ? selIdx : k;
    if (i < 0 || !shown[i] || (k >= 0 && i == selIdx)) continue;
    const Aircraft& a = viewAc[i];
    if (i != selIdx && (!settings.labels || a.alt == ALT_GROUND)) continue;
    int w = labelWidth(a);
    int ly = constrain((int)py[i] - 18, 2, SCREEN_H - LABEL_H - 2);
    int rx = px[i] + 16, lx = px[i] - 16 - w;
    bool rightOk = rx + w < PANEL_X - 4, leftOk = lx >= 2;
    int x = -1;
    if (i == selIdx)                                                 x = rightOk ? rx : lx;
    else if (rightOk && labelFree(boxes, nBoxes, rx, ly, w))         x = rx;
    else if (leftOk  && labelFree(boxes, nBoxes, lx, ly, w))         x = lx;
    if (x >= 0) boxes[nBoxes++] = {(int16_t)x, (int16_t)ly, (int16_t)w, (int16_t)i};
  }

  // Trails and icons far to near, so the nearest end up on top; selected last.
  for (int pass = 0; pass < 2; pass++) {
    for (int i = viewCount - 1; i >= 0; i--) {
      if (!shown[i] || (pass == 1) != (i == selIdx)) continue;
      const Aircraft& a = viewAc[i];
      float x = px[i], y = py[i];
      if (settings.trails) drawTrail(a, x, y);
      uint16_t col = altColor(a.alt);
      if (inOverhead(a)) {
        spr.drawCircle(x, y, 17, COL_ALERT);
        spr.drawCircle(x, y, 18, COL_ALERT);
      }
      if (i == selIdx) spr.drawCircle(x, y, 20, TFT_WHITE);
      if (a.alt == ALT_GROUND)      spr.fillCircle(x, y, 3, col);
      else if (a.cat[0] == 'A' && a.cat[1] == '7') {   // rotorcraft
        spr.fillCircle(x, y, 5, col);
        spr.drawLine(x - 9, y - 9, x + 9, y + 9, col);
        spr.drawLine(x - 9, y + 9, x + 9, y - 9, col);
      }
      else if (a.track < 0)         spr.fillCircle(x, y, 6, col);
      else                          drawPlane(x, y, a.track, planeSize(a), col);
      if (hitCount < MAX_AIRCRAFT) hits[hitCount++] = {(int16_t)x, (int16_t)y, (int16_t)i};
    }
  }
  // Labels on top of every icon; the selected one (placed first) drawn last.
  for (int b = nBoxes - 1; b >= 0; b--) {
    const LabelBox& l = boxes[b];
    drawLabel(viewAc[l.index], l.x, l.y, l.w, l.index == selIdx);
  }
}

void drawNoHome() {
  spr.setTextDatum(MC_DATUM);
  useFont(font24);
  spr.setTextColor(TFT_WHITE);
  spr.drawString("Set your home location", RADAR_CX, RADAR_CY - 60);
  useFont(font20);
  spr.setTextColor(COL_DIM_TEXT);
  String ip = currentIp();
  spr.drawString("in the web settings:", RADAR_CX, RADAR_CY - 24);
  spr.setTextColor(COL_ACCENT);
  spr.drawString(String("http://") + MDNS_NAME + ".local", RADAR_CX, RADAR_CY + 10);
  if (ip.length()) spr.drawString("http://" + ip, RADAR_CX, RADAR_CY + 40);
}

// ── Info panel ──────────────────────────────────────────────────────────────
void drawClock(const struct tm* ti) {
  int cx = PANEL_X + PANEL_W / 2;
  spr.setTextColor(TFT_WHITE);
  if (!ti) {
    useFont(font56);
    spr.setTextDatum(MC_DATUM);
    spr.drawString("--:--", cx, 50);
    return;
  }
  String digits;
  const char* suffix = "";
  if (settings.format_24h) digits = pad2(ti->tm_hour) + ":" + pad2(ti->tm_min);
  else {
    int h12 = ti->tm_hour % 12; if (h12 == 0) h12 = 12;
    digits = String(h12) + ":" + pad2(ti->tm_min);
    suffix = ti->tm_hour < 12 ? "AM" : "PM";
  }
  useFont(fontTime);
  int dw = spr.textWidth(digits);
  useFont(font24);
  int sw = *suffix ? 8 + spr.textWidth(suffix) : 0;
  int x = cx - (dw + sw) / 2, base = 80;
  spr.setTextDatum(L_BASELINE);
  useFont(fontTime);
  spr.drawString(digits, x, base);
  if (*suffix) {
    useFont(font24);
    spr.drawString(suffix, x + dw + 8, base);
  }
  useFont(font20);
  spr.setTextDatum(MC_DATUM);
  spr.setTextColor(COL_DIM_TEXT);
  spr.drawString(String(dayNames[ti->tm_wday]) + " " + ti->tm_mday + " " + monthNames[ti->tm_mon],
                 cx, 104);
}

void drawList(uint32_t now) {
  listCount = 0;
  int x0 = PANEL_X + 8, w = PANEL_W - 16;
  if (!homeSet()) return;
  if (viewCount == 0) {
    useFont(font20);
    spr.setTextDatum(MC_DATUM);
    spr.setTextColor(COL_DIM_TEXT);
    spr.drawString(feed.okAt ? "No aircraft in range" : "Waiting for data...",
                   PANEL_X + PANEL_W / 2, LIST_Y + 100);
    return;
  }
  // Airborne aircraft first, nearest first; then any on the ground.
  for (int k = 0; k < viewCount * 2 && listCount < LIST_ROWS; k++) {
    int i = k % viewCount;
    if ((viewAc[i].alt == ALT_GROUND) != (k >= viewCount)) continue;
    const Aircraft& a = viewAc[i];
    int y = LIST_Y + listCount * LIST_ROW_H;
    listIndex[listCount++] = i;
    double lat, lon;
    extrapolate(a, now, lat, lon);
    float d = distanceNm(settings.home_lat, settings.home_lon, lat, lon);
    float b = bearingDeg(settings.home_lat, settings.home_lon, lat, lon);

    spr.fillRoundRect(x0, y, w, LIST_ROW_H - 6, 6, COL_ROW);
    spr.fillRoundRect(x0, y, 6, LIST_ROW_H - 6, 3, altColor(a.alt));
    spr.setTextDatum(TL_DATUM);
    useFont(font24);
    spr.setTextColor(TFT_WHITE);
    spr.drawString(aircraftName(a), x0 + 16, y + 3);
    spr.setTextDatum(TR_DATUM);
    useFont(font20);
    spr.setTextColor(COL_DIM_TEXT);
    spr.drawString(a.type[0] ? a.type : a.cat, x0 + w - 10, y + 5);
    spr.setTextDatum(TL_DATUM);
    useFont(font16);
    spr.setTextColor(altColor(a.alt));
    int ax = x0 + 16 + spr.drawString(altString(a.alt), x0 + 16, y + 30);
    spr.setTextColor(COL_DIM_TEXT);
    String rest = (a.gs >= 0 ? "  " + String(a.gs) + " kt" : String("")) + "  " + nmString(d) +
                  " nm " + compass8(b);
    spr.drawString(rest, ax, y + 30);
  }
}

void drawDetailRow(int y, const char* label, const String& value, uint16_t col = TFT_WHITE) {
  useFont(font20);
  spr.setTextDatum(TL_DATUM);
  spr.setTextColor(COL_DIM_TEXT);
  spr.drawString(label, PANEL_X + 18, y);
  spr.setTextDatum(TR_DATUM);
  spr.setTextColor(col);
  spr.drawString(value, SCREEN_W - 18, y);
}

void drawDetail(const Aircraft& a, uint32_t now) {
  int x0 = PANEL_X + 8, w = PANEL_W - 16;
  spr.fillRoundRect(x0, LIST_Y, w, STATUS_Y - LIST_Y - 6, 8, COL_ROW);
  spr.fillRoundRect(x0, LIST_Y, w, 6, 3, altColor(a.alt));
  spr.setTextDatum(TL_DATUM);
  useFont(font32);
  spr.setTextColor(TFT_WHITE);
  spr.drawString(aircraftName(a), PANEL_X + 18, LIST_Y + 14);
  useFont(font20);
  spr.setTextColor(COL_DIM_TEXT);
  String sub = a.type;
  if (a.reg[0] && strcmp(a.reg, a.flight)) sub += (sub.length() ? "  " : "") + String(a.reg);
  String hex = a.hex; hex.toUpperCase();
  sub += (sub.length() ? "  " : "") + hex;
  spr.drawString(sub, PANEL_X + 18, LIST_Y + 50);

  double lat, lon;
  extrapolate(a, now, lat, lon);
  float d = distanceNm(settings.home_lat, settings.home_lon, lat, lon);
  float b = bearingDeg(settings.home_lat, settings.home_lon, lat, lon);
  int y = LIST_Y + 84;
  const int step = 31;
  drawDetailRow(y, "Altitude", altString(a.alt) + (a.alt > ALT_GROUND && a.alt < 18000 ? " ft" : ""),
                altColor(a.alt));                                          y += step;
  drawDetailRow(y, "Vertical", a.rate ? (a.rate > 0 ? "+" : "") + String(a.rate) + " fpm" : "level"); y += step;
  drawDetailRow(y, "Speed", a.gs >= 0 ? String(a.gs) + " kt" : "-");       y += step;
  drawDetailRow(y, "Track", a.track >= 0 ? String(a.track) + "\xC2\xB0" : "-"); y += step;
  drawDetailRow(y, "From home", nmString(d) + " nm " + compass8(b));       y += step;
  drawDetailRow(y, "Squawk", a.squawk[0] ? a.squawk : "-",
                !strcmp(a.squawk, "7700") || !strcmp(a.squawk, "7600") || !strcmp(a.squawk, "7500")
                  ? COL_ALERT : TFT_WHITE);
}

void drawStatusLine(uint32_t now) {
  useFont(font16);
  spr.setTextDatum(MC_DATUM);
  int cx = PANEL_X + PANEL_W / 2;
  String line;
  uint16_t col = COL_DIM_TEXT;
  bool stale = !feed.okAt || msSince(feed.okAt) > STALE_MS;
  if (!wifiOnline)            { line = "No WiFi"; col = COL_WARN; }
  else if (!homeSet())        { line = "Home location not set"; col = COL_WARN; }
  else if (stale && feed.error[0]) { line = feed.error; col = COL_WARN; }
  else if (!feed.okAt)        { line = "Connecting..."; }
  else {
    line = String(feed.source) + "  " + viewCount + " aircraft  " + msSince(feed.okAt) / 1000 + "s";
    if (feed.error[0]) col = COL_WARN;     // fell back from the receiver
  }
  while (spr.textWidth(line) > PANEL_W - 12 && line.length() > 4) line.remove(line.length() - 1);
  spr.setTextColor(col);
  spr.drawString(line, cx, STATUS_Y + 6);
}

void drawRangeButtons() {
  uint16_t btn = rgb888to565(58, 58, 66);
  int y = RANGE_Y, h = RANGE_BTN_H, cy = y + h / 2;
  spr.fillRoundRect(PANEL_X + 8, y, 76, h, 10, btn);
  spr.fillRoundRect(SCREEN_W - 84, y, 76, h, 10, btn);
  spr.fillRect(PANEL_X + 8 + 38 - 14, cy - 3, 28, 6, TFT_WHITE);               // -
  spr.fillRect(SCREEN_W - 84 + 38 - 14, cy - 3, 28, 6, TFT_WHITE);             // +
  spr.fillRect(SCREEN_W - 84 + 38 - 3, cy - 14, 6, 28, TFT_WHITE);
  useFont(font24);
  spr.setTextDatum(MC_DATUM);
  spr.setTextColor(TFT_WHITE);
  spr.drawString(String(settings.range_nm) + " nm", PANEL_X + PANEL_W / 2, cy);
}

// ── Color clock face (from colorclock) ────────────────────────────────────
// Shown while no aircraft are airborne within range. Background = the time as
// RGB: R = hour/23, G = minute/59, B = second/59, each scaled to 0-255; text
// in whichever gray contrasts best.
inline uint8_t mapH(int h) { return (uint8_t)((h * 255) / 23); }
inline uint8_t mapM(int m) { return (uint8_t)((m * 255) / 59); }
inline uint8_t mapS(int s) { return (uint8_t)((s * 255) / 59); }

// Background gamma correction: the basic board's TN panel shows mid-tones
// pale. The hex and R/G/B readouts still show the uncorrected values.
uint8_t gammaLut[256];

void buildGammaLut() {
  for (int i = 0; i < 256; i++) gammaLut[i] = (uint8_t)lroundf(powf(i / 255.0f, settings.gamma) * 255.0f);
}

static uint16_t linearise(uint8_t c) {
  float cf  = c / 255.0f;
  float lin = (cf <= 0.04045f) ? (cf / 12.92f) : powf((cf + 0.055f) / 1.055f, 2.4f);
  return (uint16_t)(lin * 1000.0f);
}

static uint32_t luminance1000(uint8_t r, uint8_t g, uint8_t b) {
  return (212UL * linearise(r) + 715UL * linearise(g) + 72UL * linearise(b)) / 1000UL;
}

// WCAG contrast ratio x100 between two luminances (x1000).
static uint32_t contrastRatio100(uint32_t L1, uint32_t L2) {
  uint32_t hi = max(L1, L2) + 50, lo = min(L1, L2) + 50;
  return (hi * 100UL) / lo;
}

uint16_t bestTextColor(uint8_t r, uint8_t g, uint8_t b) {
  uint32_t bgLum = luminance1000(r, g, b);
  static const uint8_t grays[] = {255, 0, 180, 80};
  uint32_t bestCR = 0;
  uint16_t bestCol = TFT_WHITE;
  for (uint8_t v : grays) {
    uint32_t cr = contrastRatio100(bgLum, luminance1000(v, v, v));
    if (cr > bestCR) { bestCR = cr; bestCol = rgb888to565(v, v, v); }
  }
  return bestCol;
}

// Digits only ("13:05:09" or "1:05:09"); AM/PM drawn separately.
String clockDigits(const struct tm& ti) {
  String out;
  if (settings.format_24h) out = pad2(ti.tm_hour);
  else { int h12 = ti.tm_hour % 12; out = String(h12 ? h12 : 12); }
  out += ":" + pad2(ti.tm_min);
  if (settings.show_seconds) out += ":" + pad2(ti.tm_sec);
  return out;
}

void drawColorClock(const struct tm* ti) {
  if (!ti) {   // no time yet (basic board before NTP): plain screen
    drawStatus("Overhead", "Waiting for the time...", TFT_CYAN);
    presentFrame();
    return;
  }
  uint8_t R = mapH(ti->tm_hour), G = mapM(ti->tm_min), B = mapS(ti->tm_sec);
  uint8_t dR = gammaLut[R], dG = gammaLut[G], dB = gammaLut[B];   // as displayed
  uint16_t bg = rgb888to565(dR, dG, dB);
  uint16_t fg = bestTextColor(dR, dG, dB);
  spr.fillSprite(bg);
  spr.setTextColor(fg, bg);
  spr.setTextDatum(MC_DATUM);

  char hex[8];
  snprintf(hex, sizeof(hex), "#%02X%02X%02X", R, G, B);
  useFont(font56);
  spr.drawString(hex, SCREEN_W / 2, 50);

  // Time: digits pre-rendered at the size for this format, AM/PM beside them.
  String digits = clockDigits(*ti);
  const char* suffix = settings.format_24h ? "" : ti->tm_hour < 12 ? "AM" : "PM";
  SmoothFont& tf = !settings.show_seconds ? fontTimeL : settings.format_24h ? fontTimeM : fontTimeS;
  useFont(tf);
  int digitsW = spr.textWidth(digits), digitsH = spr.fontHeight(), suffixW = 0;
  if (*suffix) { useFont(font56); suffixW = TIME_SUFFIX_GAP + spr.textWidth(suffix); }
  int x = (SCREEN_W - digitsW - suffixW) / 2;
  int baseline = (settings.show_date ? 205 : 240) + digitsH / 2;
  spr.setTextDatum(L_BASELINE);
  useFont(tf);
  spr.drawString(digits, x, baseline);
  if (*suffix) { useFont(font56); spr.drawString(suffix, x + digitsW + TIME_SUFFIX_GAP, baseline); }
  spr.setTextDatum(MC_DATUM);

  if (settings.show_date) {
    useFont(font56);
    spr.drawString(String(dayNames[ti->tm_wday]) + "  " + pad2(ti->tm_mday) + " " +
                   monthNames[ti->tm_mon] + " " + String(1900 + ti->tm_year), SCREEN_W / 2, 365);
  }
  useFont(font24);
  char rgb[28];
  snprintf(rgb, sizeof(rgb), "R:%3d   G:%3d   B:%3d", R, G, B);
  spr.drawString(rgb, SCREEN_W / 2, 450);

  // Corner tag when the sky only looks empty because there's no data.
  const char* tag = !wifiOnline ? "No WiFi"
                  : (!feed.okAt || msSince(feed.okAt) > STALE_MS) ? "No aircraft data" : nullptr;
  if (tag) {
    spr.setTextDatum(TR_DATUM);
    spr.drawString(tag, SCREEN_W - 16, 12);
    spr.setTextDatum(MC_DATUM);
  }
  presentFrame();
}

// Which view the main screen shows when there's no overhead card.
uint32_t lastAircraftAt = 0;      // millis() when aircraft were last in range; 0 = never
uint32_t peekUntil = 0;           // radar forced on by a tap on the clock; 0 = none

int aircraftInRange() {
  int n = 0;
  for (int i = 0; i < viewCount; i++) {
    if (viewAc[i].alt != ALT_GROUND && viewAc[i].dist_nm <= settings.range_nm) n++;
  }
  return n;
}

// Radar while aircraft are airborne within range; the color clock once the sky
// has been empty (or the feed down) for CLOCK_AFTER_MS, or before any aircraft
// have been seen. A tap on the clock peeks at the radar for PEEK_MS.
bool showClockFace() {
  if (!settings.color_clock || !homeSet()) return false;
  uint32_t now = millis();
  if (peekUntil && (int32_t)(now - peekUntil) < 0) return false;
  peekUntil = 0;
  bool fresh = feed.okAt && msSince(feed.okAt) <= STALE_MS;
  if (fresh && aircraftInRange() > 0) lastAircraftAt = now | 1;
  return !lastAircraftAt || msSince(lastAircraftAt) >= CLOCK_AFTER_MS;
}

void drawFrame(const struct tm* ti) {
  uint32_t now = millis();
  if (selHex[0] && ((int32_t)(now - selUntil) >= 0 || findAircraft(selHex) < 0)) selHex[0] = 0;

  drawRadarBackground();
  if (homeSet()) drawAircraft(now); else { hitCount = 0; drawNoHome(); }

  spr.fillRect(PANEL_X, 0, PANEL_W, SCREEN_H, COL_PANEL);
  spr.drawFastVLine(PANEL_X, 0, SCREEN_H, COL_RING);
  drawClock(ti);
  spr.drawFastHLine(PANEL_X + 12, 120, PANEL_W - 24, COL_RING);
  int sel = selHex[0] ? findAircraft(selHex) : -1;
  if (sel >= 0) { listCount = 0; drawDetail(viewAc[sel], now); }
  else drawList(now);
  drawStatusLine(now);
  drawRangeButtons();
  presentFrame();
}

// ── Overhead card ─────────────────────────────────────────────────────────
// Full screen while an airborne aircraft is within the overhead radius; closes
// once it is CARD_EXIT_FACTOR past it (or missing from 3 feeds), or on a tap.
// A dismissed aircraft doesn't reopen the card until it has left.
#define PHOTO_W 420
#define PHOTO_H 280

char        cardHex[7] = "";      // aircraft on the card; "" = no card
char        dismissedHex[7] = "";
int         cardMissing = 0;      // consecutive feeds without the card's aircraft
uint32_t    cardOpenedAt = 0;     // millis() | 1
CardInfo    card = {};            // loop's copy; card.jpg is not used here
uint32_t    cardSeenVersion = 0;
LGFX_Sprite photo;
bool        photoOk = false;

bool cardShowing() { return cardHex[0] != 0; }

void requestCard(const Aircraft& a) {
  xSemaphoreTake(dataMutex, portMAX_DELAY);
  strlcpy(cardReq.hex, a.hex, sizeof(cardReq.hex));
  strlcpy(cardReq.callsign, a.flight, sizeof(cardReq.callsign));
  cardReq.lat = a.lat;
  cardReq.lon = a.lon;
  xSemaphoreGive(dataMutex);
  if (fetchTaskHandle) xTaskNotifyGive(fetchTaskHandle);
}

void openCard(const Aircraft& a) {
  strlcpy(cardHex, a.hex, sizeof(cardHex));
  cardOpenedAt = millis() | 1;
  cardMissing = 0;
  selHex[0] = 0;
  if (strcmp(card.hex, a.hex) != 0) { memset(&card, 0, sizeof(card)); photoOk = false; }
  requestCard(a);
  float d, t;
  closestApproach(a, d, t);
  Serial.printf("Card open: %s %.2f nm, closest %.2f nm in %.0f s\n", aircraftName(a).c_str(), a.dist_nm, d, t);
}

void closeCard(const char* why) {
  Serial.printf("Card closed (%s) after %lu s\n", why, (unsigned long)(msSince(cardOpenedAt) / 1000));
  cardHex[0] = 0;
}

// Where the aircraft passes closest to home if it holds its track and speed:
// distance (nm) and seconds from now (negative = already past). Without a
// track / speed it's just the current distance, now.
void closestApproach(const Aircraft& a, float& dNm, float& tSec) {
  double lat, lon;
  extrapolate(a, millis(), lat, lon);
  float px = (float)((lon - settings.home_lon) * 60.0 * cos(settings.home_lat * DEG));
  float py = (float)((lat - settings.home_lat) * 60.0);
  dNm = sqrtf(px * px + py * py);
  tSec = 0;
  if (a.gs <= 0 || a.track < 0 || a.alt == ALT_GROUND) return;
  float vx = a.gs / 3600.0f * sinf(a.track * DEG), vy = a.gs / 3600.0f * cosf(a.track * DEG);
  tSec = -(px * vx + py * vy) / (vx * vx + vy * vy);
  if (tSec < 0) return;     // moving away: closest is now
  float cx = px + vx * tSec, cy = py + vy * tSec;
  dNm = sqrtf(cx * cx + cy * cy);
}

// Worth a card: airborne, and overhead now or about to be (within the radius
// at its closest approach in the next CARD_LEAD_S).
bool cardWorthy(const Aircraft& a, float radiusNm) {
  if (a.alt == ALT_GROUND) return false;
  if (a.dist_nm <= radiusNm) return true;
  float d, t;
  closestApproach(a, d, t);
  return d <= radiusNm && t <= CARD_LEAD_S;
}

// Called with each new feed. Opens a card ahead of the closest approach and
// keeps it up at least CARD_MIN_MS, so fast / high traffic is still readable.
void updateCard() {
  float exitNm = overheadNm() * CARD_EXIT_FACTOR;
  if (dismissedHex[0]) {
    int i = findAircraft(dismissedHex);
    if (i < 0 || !cardWorthy(viewAc[i], exitNm)) dismissedHex[0] = 0;
  }
  if (cardShowing()) {
    int i = findAircraft(cardHex);
    bool minShown = msSince(cardOpenedAt) >= CARD_MIN_MS;
    if (!settings.show_card)                    closeCard("turned off");
    else if (i < 0)                             { if (++cardMissing >= 3) closeCard("gone"); }
    else {
      cardMissing = 0;
      if (viewAc[i].alt == ALT_GROUND)                    { if (minShown) closeCard("landed"); }
      else if (!cardWorthy(viewAc[i], exitNm) && minShown) closeCard("passed");
    }
  }
  if (!cardShowing() && settings.show_card && !configOpen) {
    float r = overheadNm();
    for (int i = 0; i < viewCount; i++) {   // nearest first
      if (cardWorthy(viewAc[i], r) && strcmp(viewAc[i].hex, dismissedHex) != 0) { openCard(viewAc[i]); break; }
    }
  }
}

// Picks up finished lookups; decodes the photo once into a PSRAM sprite.
bool pullCard() {
  uint8_t* jpg = nullptr;
  size_t len = 0;
  xSemaphoreTake(dataMutex, portMAX_DELAY);
  bool fresh = cardVersion != cardSeenVersion;
  if (fresh) {
    cardSeenVersion = cardVersion;
    card = cardShared;
    card.jpg = nullptr;
    if (cardShared.jpg && (jpg = (uint8_t*)heap_caps_malloc(cardShared.jpg_len, MALLOC_CAP_SPIRAM))) {
      memcpy(jpg, cardShared.jpg, cardShared.jpg_len);
      len = cardShared.jpg_len;
    }
  }
  xSemaphoreGive(dataMutex);
  if (!fresh) return false;
  photoOk = false;
  if (jpg) {
    if (!photo.getBuffer()) {
      photo.setPsram(true);
      photo.setColorDepth(16);
      photo.createSprite(PHOTO_W, PHOTO_H);
    }
    if (photo.getBuffer()) {
      photo.fillSprite(COL_ROW);
      photoOk = photo.drawJpg(jpg, len, 0, 0, PHOTO_W, PHOTO_H, 0, 0, 0.0f, 0.0f, lgfx::datum_t::middle_center);
      if (!photoOk) Serial.printf("Photo: couldn't decode %u bytes\n", (unsigned)len);
    }
    heap_caps_free(jpg);
  }
  return true;
}

// Shortens s with "..." until it fits w px in the current font.
String fitText(String s, int w) {
  if (spr.textWidth(s) <= w) return s;
  while (s.length() > 1 && spr.textWidth(s + "...") > w) s.remove(s.length() - 1);
  return s + "...";
}

void drawCardRow(int y, const char* label, const String& value, uint16_t col = TFT_WHITE) {
  const int x0 = 456, x1 = SCREEN_W - 20;
  useFont(font20);
  spr.setTextDatum(ML_DATUM);
  spr.setTextColor(COL_DIM_TEXT);
  spr.drawString(label, x0, y);
  useFont(font24);
  spr.setTextDatum(MR_DATUM);
  spr.setTextColor(col);
  spr.drawString(value, x1, y);
}

void drawCard(const Aircraft& a, const struct tm* ti) {
  const uint16_t BG = rgb888to565(12, 16, 24);
  uint32_t now = millis();
  uint16_t altCol = altColor(a.alt);
  bool ready = !strcmp(card.hex, a.hex) && card.done;
  spr.fillSprite(BG);
  spr.fillRect(0, 0, 10, SCREEN_H, altCol);

  // Header: callsign, operator; distance from home on the right.
  double lat, lon;
  extrapolate(a, now, lat, lon);
  float dMi = distanceNm(settings.home_lat, settings.home_lon, lat, lon) / NM_PER_MI;
  float b = bearingDeg(settings.home_lat, settings.home_lon, lat, lon);
  useFont(font20);
  spr.setTextDatum(TR_DATUM);
  float cpaNm, cpaS;
  closestApproach(a, cpaNm, cpaS);
  String state = dMi * NM_PER_MI <= overheadNm() ? String("OVERHEAD")
               : cpaS > 2 ? "OVERHEAD IN " + String((int)lroundf(cpaS)) + " s"
               : String("PASSED");
  spr.setTextColor(COL_ALERT);
  spr.drawString(state, SCREEN_W - 20, 16);
  useFont(font32);
  spr.setTextColor(TFT_WHITE);
  int distW = spr.drawString((dMi < 10 ? String(dMi, 1) : String((int)lroundf(dMi))) + " mi " + compass8(b),
                             SCREEN_W - 20, 44);
  useFont(font56);
  spr.setTextDatum(TL_DATUM);
  spr.drawString(fitText(aircraftName(a), SCREEN_W - 70 - max(distW, 120)), 28, 8);
  useFont(font24);
  spr.setTextColor(COL_DIM_TEXT);
  String sub = ready && card.owner[0] ? String(card.owner) : String(ready ? "" : "Looking up...");
  spr.drawString(fitText(sub, SCREEN_W - 48), 28, 70);

  // Photo, or a big silhouette pointing along the track.
  const int px = 20, py = 108;
  if (photoOk && ready) {
    photo.pushSprite(&spr, px, py);
    useFont(font16);
    spr.setTextDatum(TL_DATUM);
    spr.setTextColor(COL_DIM_TEXT);
    spr.drawString(fitText(String(card.photographer) + " / planespotters.net", PHOTO_W),
                   px, py + PHOTO_H + 6);
  } else {
    spr.fillRoundRect(px, py, PHOTO_W, PHOTO_H, 10, COL_ROW);
    drawPlane(px + PHOTO_W / 2, py + PHOTO_H / 2, a.track >= 0 ? a.track : 0, 200, altCol);
  }

  // Right column: route, model, registration / type, live values.
  const int x0 = 456, w = SCREEN_W - 20 - x0;
  spr.setTextDatum(TL_DATUM);
  if (ready && card.from_code[0]) {
    useFont(font40);
    spr.setTextColor(TFT_WHITE);
    spr.drawString(String(card.from_code) + " \xE2\x86\x92 " + card.to_code, x0, py - 4);
    useFont(font20);
    spr.setTextColor(COL_DIM_TEXT);
    spr.drawString(fitText(String(card.from_city) + " \xE2\x86\x92 " + card.to_city, w), x0, py + 42);
  } else {
    useFont(font24);
    spr.setTextColor(COL_DIM_TEXT);
    spr.drawString(ready ? "Route unknown" : "", x0, py + 6);
  }
  useFont(font24);
  spr.setTextColor(TFT_WHITE);
  String model = ready && card.model[0] ? String(card.model) : String(a.type);
  spr.drawString(fitText(model, w), x0, py + 78);
  useFont(font20);
  spr.setTextColor(COL_DIM_TEXT);
  String ids = a.reg;
  if (a.type[0]) ids += (ids.length() ? "  " : "") + String(a.type);
  String hex = a.hex; hex.toUpperCase();
  ids += (ids.length() ? "  " : "") + hex;
  spr.drawString(fitText(ids, w), x0, py + 110);

  int y = py + 160;
  const int step = 36;
  drawCardRow(y, "Altitude", altString(a.alt) + (a.alt > ALT_GROUND && a.alt < 18000 ? " ft" : ""), altCol);
  y += step;
  drawCardRow(y, "Vertical", a.rate ? (a.rate > 0 ? "+" : "") + String(a.rate) + " fpm" : "level"); y += step;
  drawCardRow(y, "Speed", a.gs >= 0 ? String(a.gs) + " kt" : "-");                                 y += step;
  drawCardRow(y, "Track", a.track >= 0 ? String(a.track) + "\xC2\xB0 " + compass8(a.track) : "-");  y += step;
  if (a.squawk[0]) {
    bool emergency = !strcmp(a.squawk, "7700") || !strcmp(a.squawk, "7600") || !strcmp(a.squawk, "7500");
    drawCardRow(y, "Squawk", a.squawk, emergency ? COL_ALERT : TFT_WHITE);
  }

  // Footer: time and how to close.
  useFont(font20);
  spr.setTextColor(COL_DIM_TEXT);
  spr.setTextDatum(BL_DATUM);
  if (ti) {
    char t[12];
    if (settings.format_24h) snprintf(t, sizeof(t), "%02d:%02d", ti->tm_hour, ti->tm_min);
    else snprintf(t, sizeof(t), "%d:%02d %s", ti->tm_hour % 12 ? ti->tm_hour % 12 : 12, ti->tm_min,
                  ti->tm_hour < 12 ? "AM" : "PM");
    spr.drawString(t, 28, SCREEN_H - 12);
  }
  spr.setTextDatum(BR_DATUM);
  spr.drawString("Tap to close", SCREEN_W - 20, SCREEN_H - 12);
  presentFrame();
}

void stepRange(int dir) {
  int i = 0;
  while (i < RANGE_COUNT - 1 && RANGE_CHOICES[i] < settings.range_nm) i++;
  i = constrain(i + dir, 0, RANGE_COUNT - 1);
  if (RANGE_CHOICES[i] == settings.range_nm) return;
  settings.range_nm = RANGE_CHOICES[i];
  Serial.printf("Range %u nm\n", settings.range_nm);
  publishFetchConfig(true);
  rangeSaveAt = (millis() + RANGE_SAVE_MS) | 1;   // save once the buttons go quiet
}

// Taps on the main view: aircraft on the radar, list rows, range buttons.
void handleViewTouch() {
  if (!touch.started) return;
  int x = touch.x, y = touch.y;
  radarDirty = true;
  if (cardShowing()) {
    strlcpy(dismissedHex, cardHex, sizeof(dismissedHex));
    closeCard("tapped");
    return;
  }
  if (clockShowing) {
    peekUntil = (millis() + PEEK_MS) | 1;
    return;
  }
  if (x < PANEL_X) {
    int best = -1, bestD = 40 * 40;
    for (int i = 0; i < hitCount; i++) {
      int dx = hits[i].x - x, dy = hits[i].y - y, d = dx * dx + dy * dy;
      if (d < bestD) { bestD = d; best = hits[i].index; }
    }
    if (best >= 0) {
      strlcpy(selHex, viewAc[best].hex, sizeof(selHex));
      selUntil = millis() + SELECT_MS;
    } else {
      selHex[0] = 0;
    }
    return;
  }
  if (y >= RANGE_Y) {
    if (x < PANEL_X + 100) stepRange(-1);
    else if (x >= SCREEN_W - 100) stepRange(1);
    return;
  }
  if (y >= LIST_Y && y < STATUS_Y) {
    if (selHex[0]) { selHex[0] = 0; return; }     // tap the detail card to close it
    int row = (y - LIST_Y) / LIST_ROW_H;
    if (row < listCount) {
      strlcpy(selHex, viewAc[listIndex[row]].hex, sizeof(selHex));
      selUntil = millis() + SELECT_MS;
    }
  }
}

// ── On-screen settings ──────────────────────────────────────────────────────
// Opened by tapping the top-left and top-right corners (either order) within
// CORNER_WINDOW_MS while the screen is lit (normal or dim). The IP address, if
// connected, is shown along the bottom. Changes apply live; Done, or
// CONFIG_IDLE_MS without a touch, saves and returns to the radar.
#define CORNER_W          160
#define CORNER_H          120
#define CORNER_WINDOW_MS  5000
#define CONFIG_IDLE_MS    60000
#define REPEAT_DELAY_MS   500     // hold +/- this long to auto-repeat
#define REPEAT_MS         120
#define DIM_PREVIEW_MS    2000    // show the dim level this long after changing it

#define TAB_W     (SCREEN_W / 6)  // 5 page tabs + Done across the top
#define HEADER_H  80
#define ROWS_Y    100
#define ROW_H     85
#define CTRL_H    64
#define FOOTER_Y  (SCREEN_H - 20)   // WiFi line, below the last row
#define WIFI_BTN_X 570              // "Change WiFi" button in the footer
#define WIFI_BTN_Y 442
#define WIFI_BTN_W 220
#define WIFI_BTN_H 36

const char* configTabs[] = {"Radar", "Clock", "Dim", "Off", "Overhead"};
int configPageCount() { return 5; }

int configRows(int page, ConfigRow* rows) {
  switch (page) {
    case 0:
      rows[0] = {"Brightness",   ROW_PERCENT, &settings.brightness, 5, 100};
      rows[1] = {"Range",        ROW_CHOICE,  &settings.range_nm, 0, 0, RANGE_CHOICES, RANGE_COUNT, "nm"};
      rows[2] = {"Labels",       ROW_TOGGLE,  &settings.labels};
      rows[3] = {"Trails",       ROW_TOGGLE,  &settings.trails};
      return 4;
    case 1:
      rows[0] = {"Color clock",  ROW_TOGGLE,  &settings.color_clock};
      rows[1] = {"24-hour",      ROW_TOGGLE,  &settings.format_24h};
      rows[2] = {"Seconds",      ROW_TOGGLE,  &settings.show_seconds};
      rows[3] = {"Date",         ROW_TOGGLE,  &settings.show_date};
      return 4;
    case 2:
      rows[0] = {"Dim screen",   ROW_TOGGLE,  &settings.dim_enabled};
      rows[1] = {"From",         ROW_TIME,    &settings.dim_start};
      rows[2] = {"Until",        ROW_TIME,    &settings.dim_end};
      rows[3] = {"Brightness",   ROW_PERCENT, &settings.dim_level, 5, 100};
      return 4;
    case 3:
      rows[0] = {"Screen off",   ROW_TOGGLE,  &settings.off_enabled};
      rows[1] = {"From",         ROW_TIME,    &settings.off_start};
      rows[2] = {"Until",        ROW_TIME,    &settings.off_end};
      return 3;
    default:
      rows[0] = {"Within",       ROW_CHOICE,  &settings.overhead_mi, 0, 0, OVERHEAD_CHOICES, OVERHEAD_COUNT, "mi"};
      rows[1] = {"Show card",    ROW_TOGGLE,  &settings.show_card};
      if (!CrowPanel7::hasBuzzer()) return 2;
      rows[2] = {"Beep",         ROW_TOGGLE,  &settings.alert};
      rows[3] = {"Test beep",    ROW_ACTION,  nullptr};
      return 4;
  }
}

int      configPage = 0;
bool     configDirty = false;     // redraw needed
uint32_t configLastTouch = 0;
uint32_t dimPreviewUntil = 0;     // 0 = no preview
int      heldRow = -1, heldDir = 0;
uint32_t nextRepeat = 0;
uint32_t cornerTapL = 0, cornerTapR = 0;   // millis() of the last tap in each top corner
String   configIp;                // IP shown in the footer; "" = not connected

void openConfig() {
  configOpen = true;
  configPage = 0;
  configDirty = true;
  configLastTouch = millis();
  heldRow = -1;
  selHex[0] = 0;
  Serial.println("On-screen settings opened");
}

void closeConfig() {
  configOpen = false;
  dimPreviewUntil = 0;
  saveSettings();
  rangeSaveAt = 0;
  publishFetchConfig(true);
  logSettings("Saved (on screen)");
  radarDirty = true;
  // Stay at normal brightness for wake_s, as after a tap, so a dim / off
  // schedule doesn't blank the screen the instant Done is pressed.
  wakeLevel = settings.brightness;
  wakeUntil = (millis() + settings.wake_s * 1000UL) | 1;
}

// A tap in one top corner, then the other within CORNER_WINDOW_MS, opens the settings.
void checkCornerTaps() {
  if (!touch.started || touch.y >= CORNER_H) return;
  uint32_t now = millis(), other;
  if (touch.x < CORNER_W)                  { cornerTapL = now | 1; other = cornerTapR; }
  else if (touch.x >= SCREEN_W - CORNER_W) { cornerTapR = now | 1; other = cornerTapL; }
  else return;
  if (other && now - other <= CORNER_WINDOW_MS) {
    cornerTapL = cornerTapR = 0;
    openConfig();
  }
}

String configTimeString(uint16_t minutes) {
  if (settings.format_24h) return hhmm(minutes);
  int h = minutes / 60, h12 = h % 12 ? h % 12 : 12;
  return String(h12) + ":" + pad2(minutes % 60) + (h < 12 ? " AM" : " PM");
}

void drawButton(int x, int y, int w, int h, uint16_t bg, const char* text, uint16_t fg) {
  spr.fillRoundRect(x, y, w, h, 12, bg);
  if (text) {
    spr.setTextColor(fg, bg);
    spr.drawString(text, x + w / 2, y + h / 2);
  }
}

// +/- drawn as bars: the fonts are ASCII-only and a text '-' is too thin to aim at.
void drawStepButton(int x, int y, int w, int h, uint16_t bg, bool plus) {
  drawButton(x, y, w, h, bg, nullptr, 0);
  int cx = x + w / 2, cy = y + h / 2;
  spr.fillRect(cx - 16, cy - 4, 32, 8, TFT_WHITE);
  if (plus) spr.fillRect(cx - 4, cy - 16, 8, 32, TFT_WHITE);
}

void drawConfig(const ConfigRow* rows, int n) {
  const uint16_t BG     = rgb888to565(18, 18, 22);
  const uint16_t PANEL  = rgb888to565(58, 58, 66);
  const uint16_t GREEN  = rgb888to565(40, 160, 90);

  spr.fillSprite(BG);
  spr.setTextDatum(MC_DATUM);
  useFont(font40);
  for (int t = 0; t < configPageCount(); t++) {
    bool active = t == configPage;
    useFont(font40);
    if (spr.textWidth(configTabs[t]) > TAB_W - 28) useFont(font32);
    if (spr.textWidth(configTabs[t]) > TAB_W - 28) useFont(font24);
    if (spr.textWidth(configTabs[t]) > TAB_W - 28) useFont(font20);
    drawButton(t * TAB_W + 6, 8, TAB_W - 12, HEADER_H - 16, active ? COL_ACCENT : PANEL,
               configTabs[t], active ? TFT_BLACK : TFT_WHITE);
  }
  useFont(font32);
  drawButton(configPageCount() * TAB_W + 6, 8, TAB_W - 12, HEADER_H - 16, GREEN, "Done", TFT_WHITE);

  for (int i = 0; i < n; i++) {
    const ConfigRow& r = rows[i];
    int cy = ROWS_Y + i * ROW_H + ROW_H / 2, top = cy - CTRL_H / 2;
    useFont(font40);
    spr.setTextDatum(ML_DATUM);
    spr.setTextColor(TFT_WHITE, BG);
    spr.drawString(r.label, 40, cy);
    spr.setTextDatum(MC_DATUM);

    if (r.kind == ROW_TOGGLE) {
      bool on = *(bool*)r.value;
      drawButton(600, top, 180, CTRL_H, on ? GREEN : PANEL, on ? "ON" : "OFF", TFT_WHITE);
    } else if (r.kind == ROW_ACTION) {
      drawButton(560, top, 220, CTRL_H, PANEL, "Play", TFT_WHITE);
    } else {
      String v = r.kind == ROW_PERCENT ? String(*(uint8_t*)r.value) + "%"
               : r.kind == ROW_CHOICE  ? String(*(uint16_t*)r.value) + " " + r.unit
                                       : configTimeString(*(uint16_t*)r.value);
      drawStepButton(410, top, 90, CTRL_H, PANEL, false);
      drawStepButton(690, top, 90, CTRL_H, PANEL, true);
      if (spr.textWidth(v) > 180) useFont(font24);
      spr.setTextColor(TFT_WHITE, BG);
      spr.drawString(v, 595, cy);
    }
  }

  // Footer: network and IP, and a button to change the network (works offline too).
  configIp = currentIp();
  useFont(font20);
  spr.setTextDatum(ML_DATUM);
  spr.setTextColor(rgb888to565(150, 150, 160), BG);
  String ssid = WiFi.SSID();
  if (!ssid.length()) ssid = portalWm.getWiFiSSID();
  String line = configIp.length() ? "WiFi: " + ssid + "   IP: " + configIp
                                  : "WiFi: not connected" + (ssid.length() ? " (" + ssid + ")" : String(""));
  spr.drawString(line, 24, FOOTER_Y);
  spr.setTextDatum(MC_DATUM);
  drawButton(WIFI_BTN_X, WIFI_BTN_Y, WIFI_BTN_W, WIFI_BTN_H, PANEL, "Change WiFi", TFT_WHITE);
  presentFrame();
}

// Percent in steps of 5; times in steps of 15 min, snapped to the quarter hour,
// wrapping at midnight; choices to the next / previous value.
void stepRow(const ConfigRow& r, int dir) {
  if (r.kind == ROW_PERCENT) {
    uint8_t* v = (uint8_t*)r.value;
    *v = constrain((int)*v + dir * 5, (int)r.min, (int)r.max);
    if (v == &settings.dim_level) dimPreviewUntil = (millis() + DIM_PREVIEW_MS) | 1;
  } else if (r.kind == ROW_TIME) {
    uint16_t* v = (uint16_t*)r.value;
    int m = dir > 0 ? (*v / 15 + 1) * 15 : ((*v + 14) / 15 - 1) * 15;
    *v = (m + 24 * 60) % (24 * 60);
  } else if (r.kind == ROW_CHOICE) {
    uint16_t* v = (uint16_t*)r.value;
    int i = 0;
    while (i < r.nChoices - 1 && r.choices[i] < *v) i++;
    *v = r.choices[constrain(i + dir, 0, r.nChoices - 1)];
  }
  configDirty = true;
}

void handleConfigTouch(const ConfigRow* rows, int n) {
  int x = touch.x, y = touch.y;
  if (y < HEADER_H) {
    int slot = x / TAB_W;
    if (slot == configPageCount()) { closeConfig(); return; }
    if (slot < configPageCount() && slot != configPage) { configPage = slot; configDirty = true; }
    return;
  }
  if (y >= WIFI_BTN_Y - 10 && x >= WIFI_BTN_X) {
    closeConfig();
    startPortal("Opened from the on-screen settings");
    return;
  }
  int i = (y - ROWS_Y) / ROW_H;
  if (y < ROWS_Y || i >= n) return;
  const ConfigRow& r = rows[i];
  if (r.kind == ROW_TOGGLE && x >= 560) {
    *(bool*)r.value = !*(bool*)r.value;
    configDirty = true;
  } else if (r.kind == ROW_ACTION && x >= 520) {
    startBeep();
  } else if (r.kind == ROW_PERCENT || r.kind == ROW_TIME || r.kind == ROW_CHOICE) {
    int dir = x >= 380 && x < 520 ? -1 : x >= 670 ? 1 : 0;
    if (!dir) return;
    stepRow(r, dir);
    heldRow = i; heldDir = dir;
    nextRepeat = millis() + REPEAT_DELAY_MS;
  }
}

// One loop pass while the settings are open.
void runConfig() {
  uint32_t now = millis();
  ConfigRow rows[4];
  int n = configRows(configPage, rows);

  if (touch.down) configLastTouch = now;
  if (!touch.down) heldRow = -1;
  if (touch.started) {
    heldRow = -1;
    handleConfigTouch(rows, n);
    if (!configOpen) return;
    n = configRows(configPage, rows);   // the page may have changed
  } else if (heldRow >= 0 && (int32_t)(now - nextRepeat) >= 0) {
    stepRow(rows[heldRow], heldDir);
    nextRepeat = now + REPEAT_MS;
  }
  if (now - configLastTouch >= CONFIG_IDLE_MS) { closeConfig(); return; }

  if (dimPreviewUntil && (int32_t)(now - dimPreviewUntil) >= 0) dimPreviewUntil = 0;
  setBacklightLevel(dimPreviewUntil ? min(settings.dim_level, settings.brightness)
                                    : settings.brightness, "settings");

  if (currentIp() != configIp) configDirty = true;
  if (configDirty) {
    configDirty = false;
    drawConfig(rows, n);
  } else {
    delay(20);
  }
}

// ── Setup ───────────────────────────────────────────────────────────────────
void setup() {
  Serial.begin(115200);
  Serial.printf("Board: %s\n", CrowPanel7::boardName());

  if (!display.begin()) {
    Serial.println("Display init failed — is OPI PSRAM enabled in the board options?");
    while (true) delay(1000);
  }
  bindSprite();
  loadFonts();
  initColors();
  spr.setTextDatum(MC_DATUM);

  loadSettings();
  buildGammaLut();
  restoreTimeFromRtc();
  trails = (Trail*)heap_caps_calloc(MAX_TRAILS, sizeof(Trail), MALLOC_CAP_SPIRAM);

  Serial.printf("Display %dx%d, double-buffered, %.1f fps; free internal RAM %u KB, PSRAM %u KB\n",
                SCREEN_W, SCREEN_H, display.measureFps(),
                heap_caps_get_free_size(MALLOC_CAP_INTERNAL) / 1024,
                heap_caps_get_free_size(MALLOC_CAP_SPIRAM) / 1024);
  logSettings("Loaded");

  // First frame is drawn into a framebuffer before the backlight comes on,
  // so the panel never shows uninitialized memory.
  showStatus("Overhead", "Starting...", TFT_CYAN);
  backlightLevel = settings.brightness;
  display.setBrightness(backlightLevel);

  setupWiFi();
  applyTimeSettings();
  setupWebServer();
  startFetchTask();
  if (bootPortal) startPortal("Saved network didn't connect. The clock keeps running.");
}

// ── Loop ────────────────────────────────────────────────────────────────────
void loop() {
  server.handleClient();
  checkWiFi();
  updateBeep();
  pollTouch();

  if (ntpSynced) {
    ntpSynced = false;
    if (display.writeRtc(time(nullptr))) Serial.println("RTC set from NTP");
  }

  if (portalOpen) {
    struct tm pt;
    bool pk = localTimeNow(&pt);
    runPortal(pk ? &pt : nullptr);
    return;
  }

  if (configOpen) {
    runConfig();
    return;
  }

  if (rangeSaveAt && (int32_t)(millis() - rangeSaveAt) >= 0) {
    rangeSaveAt = 0;
    saveSettings();
    logSettings("Saved (range)");
  }

  struct tm ti;
  bool haveTime = localTimeNow(&ti);
  currentSchedule = haveTime ? scheduleAt(ti) : SCHED_NORMAL;

  // A tap that wakes a dark screen does only that. Corner taps count whenever
  // the screen was visible, so the settings open from dim too.
  bool wasVisible = backlightLevel > 0;
  bool wokeOnly = updateScreenPower(currentSchedule);
  if (wasVisible) checkCornerTaps();
  if (configOpen) return;
  if (!wokeOnly && wasVisible) handleViewTouch();

  if (pullFeed()) {
    updateTrails();
    checkAlerts();
    updateCard();
    radarDirty = true;
  }
  if (pullCard()) radarDirty = true;

  static uint32_t lastDraw = 0;
  static int lastSec = -1;
  if (clockShowing && haveTime && ti.tm_sec != lastSec) radarDirty = true;   // clock face ticks on the second
  if (haveTime) lastSec = ti.tm_sec;
  if (radarDirty || millis() - lastDraw >= REDRAW_MS) {
    radarDirty = false;
    lastDraw = millis();
    int c = cardShowing() ? findAircraft(cardHex) : -1;
    bool clock = c < 0 && showClockFace();
    if (clock != clockShowing) {
      clockShowing = clock;
      Serial.println(clock ? "View: color clock (no aircraft in range)" : "View: radar");
    }
    if (c >= 0)     drawCard(viewAc[c], haveTime ? &ti : nullptr);
    else if (clock) drawColorClock(haveTime ? &ti : nullptr);
    else            drawFrame(haveTime ? &ti : nullptr);
  } else {
    delay(beepStep ? 5 : 15);
  }
}
